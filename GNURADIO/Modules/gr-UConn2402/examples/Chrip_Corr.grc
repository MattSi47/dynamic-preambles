options:
  parameters:
    generate_options: qt_gui
    id: Chirp_Corr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Chirp
  id: variable_qtgui_chooser
  parameters:
    label: Chirp
    label0: Up Chirp
    label1: Down Chirp
    num_opts: '2'
    option0: (complex(1.000000,0.951178), complex(0.809939,0.590641), complex(0.314987,0.009817), complex(-0.295541,-0.572110), complex(-0.793990,-0.940748), complex(-0.999229,-0.964661), complex(-0.840945,-0.640143), complex(-0.381232,-0.088242), complex(0.212007,0.492386), complex(0.727892,0.897855), complex(0.987688,0.990079), complex(0.905495,0.742005), complex(0.514440,0.242980), complex(-0.048675,-0.335410), complex(-0.592857,-0.799449), complex(-0.938191,-0.998002), complex(-0.974527,-0.870377), complex(-0.694784,-0.462716), complex(-0.193549,0.090589), complex(0.366664,0.612597), complex(0.809017,0.940748), complex(0.997927,0.976682), complex(0.879316,0.714015), complex(0.494094,0.236881), complex(-0.037690,-0.308643), complex(-0.555570,-0.760151), complex(-0.907484,-0.987129), complex(-0.993787,-0.927592), complex(-0.793990,-0.603243), complex(-0.369585,-0.110125), complex(0.156434,0.411156), complex(0.636213,0.816112), complex(0.938734,0.996099), complex(0.984838,0.906326), complex(0.766493,0.575326), complex(0.346117,0.094499), complex(-0.162637,-0.408291), complex(-0.626468,-0.803208), complex(-0.927445,-0.991666), complex(-0.992310,-0.929921), complex(-0.809017,-0.637727), complex(-0.427200,-0.190852), complex(0.056519,0.299665), complex(0.523837,0.715662), complex(0.863923,0.960184), complex(0.999229,0.979302), complex(0.902134,0.772761), complex(0.599163,0.391735), complex(0.162637,-0.074935), complex(-0.307523,-0.522164), complex(-0.707107,-0.852435), complex(-0.950570,-0.996634), complex(-0.988652,-0.927592), complex(-0.817245,-0.663959), complex(-0.476238,-0.264252), complex(-0.039260,0.186996), complex(0.402906,0.597590), complex(0.761425,0.886507), complex(0.967001,0.999389), complex(0.982580,0.917911), complex(0.809017,0.661606), complex(0.483130,0.282383), complex(0.069060,-0.146730), complex(-0.354944,-0.546065), complex(-0.711536,-0.844117), complex(-0.938191,-0.989968), complex(-0.997613,-0.961274), complex(-0.883030,-0.766745), complex(-0.617860,-0.443110), complex(-0.250211,-0.047499), complex(0.156434,0.353107), complex(0.534500,0.693370), complex(0.823533,0.920078), complex(0.979540,0.999994), complex(0.981091,0.924030), complex(0.831470,0.707384), complex(0.556876,0.385946), complex(0.201249,0.009817), complex(-0.181206,-0.364836), complex(-0.534500,-0.684261), complex(-0.809017,-0.904660), complex(-0.968191,-0.997799), complex(-0.992883,-0.954044), complex(-0.883030,-0.782635), complex(-0.656586,-0.509379), complex(-0.346117,-0.172316), complex(0.006283,0.183908), complex(0.354944,0.514103), complex(0.656586,0.778216), complex(0.875549,0.945958), complex(0.987688,0.999883), complex(0.982580,0.936687), complex(0.863923,0.766745), complex(0.648253,0.512080), complex(0.362275,0.203172), complex(0.039260,-0.124944), complex(-0.285019,-0.436763), complex(-0.576290,-0.700131), complex(-0.805308,-0.889396), complex(-0.950570,-0.987627), complex(-1.000000,-0.987750), complex(-0.951541,-0.892605), complex(-0.812694,-0.714015), complex(-0.599163,-0.471050), complex(-0.332820,-0.187767), complex(-0.039260,0.109344), complex(0.254771,0.393902), complex(0.523837,0.641952), complex(0.745941,0.833862), complex(0.904157,0.955677), complex(0.987688,0.999870), complex(0.992310,0.965484), complex(0.920232,0.857729), complex(0.779447,0.687119), complex(0.582690,0.468277), complex(0.346117,0.218526), complex(0.087851,-0.043576), complex(-0.173476,-0.299665), complex(-0.420086,-0.532839), complex(-0.636213,-0.728700), complex(-0.809017,-0.876117), complex(-0.929197,-0.967698), complex(-0.991308,-0.999952), complex(-0.993787,-0.973189), complex(-0.938734,-0.891185), complex(-0.831470,-0.760661), complex(-0.679953,-0.590641), complex(-0.494094,-0.391735), complex(-0.285019,-0.175410), complex(-0.064358,0.046714), complex(0.156434,0.263494), complex(0.366664,0.464803), complex(0.556876,0.641952), complex(0.719219,0.787984), complex(0.847678,0.897855), complex(0.938191,0.968485), complex(0.988652,0.998717), complex(0.998815,0.989177), complex(0.970127,0.942072), complex(0.905495,0.860942), complex(0.809017,0.750371), complex(0.685691,0.615696), complex(0.541121,0.462716), complex(0.381232,0.297417), complex(0.212007,0.125723), complex(0.039260,-0.046714), complex(-0.131564,-0.214693), complex(-0.295541,-0.373595), complex(-0.448383,-0.519482), complex(-0.586514,-0.649149), complex(-0.707107,-0.760151), complex(-0.808093,-0.850788), complex(-0.888136,-0.920078), complex(-0.946593,-0.967698), complex(-0.983445,-0.993918), complex(-0.999229,-0.999519), complex(-0.994951,-0.985711), complex(-0.972002,-0.954044), complex(-0.932071,-0.906326), complex(-0.877062,-0.844538), complex(-0.809017,-0.770763), complex(-0.730043,-0.687119), complex(-0.642253,-0.595699), complex(-0.547709,-0.498526), complex(-0.448383,-0.397508), complex(-0.346117,-0.294416), complex(-0.242599,-0.190852), complex(-0.139346,-0.088242), complex(-0.037690,0.012173), complex(0.061223,0.109344), complex(0.156434,0.202403), complex(0.247168,0.290660), complex(0.332820,0.373595), complex(0.412945,0.450839), complex(0.487250,0.522164), complex(0.555570,0.587468), complex(0.617860,0.646757), complex(0.674173,0.700131), complex(0.724653,0.747769), complex(0.769511,0.789914), complex(0.809017,0.826860), complex(0.843485,0.858938), complex(0.873262,0.886507), complex(0.898718,0.909943), complex(0.920232,0.929632), complex(0.938191,0.945958), complex(0.952979,0.959302), complex(0.964971,0.970031), complex(0.974527,0.978500), complex(0.981992,0.985042), complex(0.987688,0.989968), complex(0.991917,0.993567), complex(0.994951,0.996099), complex(0.997039,0.997799), complex(0.998402,0.998871), complex(0.999229,0.999494), complex(0.999684,0.999815), complex(0.999900,0.999952), complex(0.999980,0.999994), complex(0.999999,1.000000), complex(1.000000,1.000000), complex(0.999999,0.999994), complex(0.999980,0.999952), complex(0.999900,0.999815), complex(0.999684,0.999494), complex(0.999229,0.998871), complex(0.998402,0.997799), complex(0.997039,0.996099), complex(0.994951,0.993567), complex(0.991917,0.989968), complex(0.987688,0.985042), complex(0.981992,0.978500), complex(0.974527,0.970031), complex(0.964971,0.959302), complex(0.952979,0.945958), complex(0.938191,0.929632), complex(0.920232,0.909943), complex(0.898718,0.886507), complex(0.873262,0.858938), complex(0.843485,0.826860), complex(0.809017,0.789914), complex(0.769511,0.747769), complex(0.724653,0.700131), complex(0.674173,0.646757), complex(0.617860,0.587468), complex(0.555570,0.522164), complex(0.487250,0.450839), complex(0.412945,0.373595), complex(0.332820,0.290660), complex(0.247168,0.202403), complex(0.156434,0.109344), complex(0.061223,0.012173), complex(-0.037690,-0.088242), complex(-0.139346,-0.190852), complex(-0.242599,-0.294416), complex(-0.346117,-0.397508), complex(-0.448383,-0.498526), complex(-0.547709,-0.595699), complex(-0.642253,-0.687119), complex(-0.730043,-0.770763), complex(-0.809017,-0.844538), complex(-0.877062,-0.906326), complex(-0.932071,-0.954044), complex(-0.972002,-0.985711), complex(-0.994951,-0.999519), complex(-0.999229,-0.993918), complex(-0.983445,-0.967698), complex(-0.946593,-0.920078), complex(-0.888136,-0.850788), complex(-0.808093,-0.760151), complex(-0.707107,-0.649149), complex(-0.586514,-0.519482), complex(-0.448383,-0.373595), complex(-0.295541,-0.214693), complex(-0.131564,-0.046714), complex(0.039260,0.125723), complex(0.212007,0.297417), complex(0.381232,0.462716), complex(0.541121,0.615696), complex(0.685691,0.750371), complex(0.809017,0.860942), complex(0.905495,0.942072), complex(0.970127,0.989177), complex(0.998815,0.998717), complex(0.988652,0.968485), complex(0.938191,0.897855), complex(0.847678,0.787984), complex(0.719219,0.641952), complex(0.556876,0.464803), complex(0.366664,0.263494), complex(0.156434,0.046714), complex(-0.064358,-0.175410), complex(-0.285019,-0.391735), complex(-0.494094,-0.590641), complex(-0.679953,-0.760661), complex(-0.831470,-0.891185), complex(-0.938734,-0.973189), complex(-0.993787,-0.999952), complex(-0.991308,-0.967698), complex(-0.929197,-0.876117), complex(-0.809017,-0.728700), complex(-0.636213,-0.532839), complex(-0.420086,-0.299665), complex(-0.173476,-0.043576), complex(0.087851,0.218526), complex(0.346117,0.468277), complex(0.582690,0.687119), complex(0.779447,0.857729), complex(0.920232,0.965484), complex(0.992310,0.999870), complex(0.987688,0.955677), complex(0.904157,0.833862), complex(0.745941,0.641952), complex(0.523837,0.393902), complex(0.254771,0.109344), complex(-0.039260,-0.187767), complex(-0.332820,-0.471050), complex(-0.599163,-0.714015), complex(-0.812694,-0.892605), complex(-0.951541,-0.987750), complex(-1.000000,-0.987627), complex(-0.950570,-0.889396), complex(-0.805308,-0.700131), complex(-0.576290,-0.436763), complex(-0.285019,-0.124944), complex(0.039260,0.203172), complex(0.362275,0.512080), complex(0.648253,0.766745), complex(0.863923,0.936687), complex(0.982580,0.999883), complex(0.987688,0.945958), complex(0.875549,0.778216), complex(0.656586,0.514103), complex(0.354944,0.183908), complex(0.006283,-0.172316), complex(-0.346117,-0.509379), complex(-0.656586,-0.782635), complex(-0.883030,-0.954044), complex(-0.992883,-0.997799), complex(-0.968191,-0.904660), complex(-0.809017,-0.684261), complex(-0.534500,-0.364836), complex(-0.181206,0.009817), complex(0.201249,0.385946), complex(0.556876,0.707384), complex(0.831470,0.924030), complex(0.981091,0.999994), complex(0.979540,0.920078), complex(0.823533,0.693370), complex(0.534500,0.353107), complex(0.156434,-0.047499), complex(-0.250211,-0.443110), complex(-0.617860,-0.766745), complex(-0.883030,-0.961274), complex(-0.997613,-0.989968), complex(-0.938191,-0.844117), complex(-0.711536,-0.546065), complex(-0.354944,-0.146730), complex(0.069060,0.282383), complex(0.483130,0.661606), complex(0.809017,0.917911), complex(0.982580,0.999389), complex(0.967001,0.886507), complex(0.761425,0.597590), complex(0.402906,0.186996), complex(-0.039260,-0.264252), complex(-0.476238,-0.663959), complex(-0.817245,-0.927592), complex(-0.988652,-0.996634), complex(-0.950570,-0.852435), complex(-0.707107,-0.522164), complex(-0.307523,-0.074935), complex(0.162637,0.391735), complex(0.599163,0.772761), complex(0.902134,0.979302), complex(0.999229,0.960184), complex(0.863923,0.715662), complex(0.523837,0.299665), complex(0.056519,-0.190852), complex(-0.427200,-0.637727), complex(-0.809017,-0.929921), complex(-0.992310,-0.991666), complex(-0.927445,-0.803208), complex(-0.626468,-0.408291), complex(-0.162637,0.094499), complex(0.346117,0.575326), complex(0.766493,0.906326), complex(0.984838,0.996099), complex(0.938734,0.816112), complex(0.636213,0.411156), complex(0.156434,-0.110125), complex(-0.369585,-0.603243), complex(-0.793990,-0.927592), complex(-0.993787,-0.987129), complex(-0.907484,-0.760151), complex(-0.555570,-0.308643), complex(-0.037690,0.236881), complex(0.494094,0.714015), complex(0.879316,0.976682), complex(0.997927,0.940748), complex(0.809017,0.612597), complex(0.366664,0.090589), complex(-0.193549,-0.462716), complex(-0.694784,-0.870377), complex(-0.974527,-0.998002), complex(-0.938191,-0.799449), complex(-0.592857,-0.335410), complex(-0.048675,0.242980), complex(0.514440,0.742005), complex(0.905495,0.990079), complex(0.987688,0.897855), complex(0.727892,0.492386), complex(0.212007,-0.088242), complex(-0.381232,-0.640143), complex(-0.840945,-0.964661), complex(-0.999229,-0.940748), complex(-0.793990,-0.572110), complex(-0.295541,0.009817), complex(0.314987,0.590641), complex(0.809939,0.951178), complex(1.000000,0.000000), complex(-0.308643,-0.586514), complex(-0.806935,-0.949096), complex(-0.999952,-0.955330), complex(-0.820177,-0.607930), complex(-0.339107,-0.039260), complex(0.263494,0.541121), complex(0.768256,0.924480), complex(0.996099,0.977268), complex(0.870377,0.685691), complex(0.440292,0.156434), complex(-0.140512,-0.424357), complex(-0.670394,-0.857527), complex(-0.970031,-0.998815), complex(-0.942072,-0.805308), complex(-0.600734,-0.346117), complex(-0.063182,0.224271), complex(0.492386,0.719219), complex(0.886507,0.981091), complex(0.995888,0.930354), complex(0.790396,0.587785), complex(0.339107,0.064358), complex(-0.214693,-0.476238), complex(-0.700131,-0.869409), complex(-0.971539,-0.999289), complex(-0.951178,-0.831470), complex(-0.649747,-0.420086), complex(-0.159924,0.111295), complex(0.373595,0.607930), complex(0.797558,0.929197), complex(0.993918,0.987688), complex(0.911565,0.771514), complex(0.577893,0.344643), complex(0.088242,-0.173476), complex(-0.422579,-0.642253), complex(-0.817924,-0.938191), complex(-0.995525,-0.986686), complex(-0.912852,-0.779447), complex(-0.595699,-0.373959), complex(-0.128839,0.123775), complex(0.367759,0.587785), complex(0.770263,0.904157), complex(0.981619,0.998402), complex(0.954044,0.851818), complex(0.698447,0.503623), complex(0.279368,0.039260), complex(-0.202403,-0.431456), complex(-0.634697,-0.800627), complex(-0.920078,-0.986686), complex(-0.997188,-0.951541), complex(-0.852845,-0.707107), complex(-0.522833,-0.310511), complex(-0.081982,0.150226), complex(0.373595,0.576290), complex(0.747769,0.879316), complex(0.964454,0.999229), complex(0.982361,0.915241), complex(0.801802,0.648253), complex(0.462716,0.254771), complex(0.034943,-0.185838), complex(-0.396787,-0.587785), complex(-0.749851,-0.875549), complex(-0.959302,-0.997613), complex(-0.989177,-0.934888), complex(-0.837743,-0.702650), complex(-0.536158,-0.346117), complex(-0.141290,0.069060), complex(0.275595,0.469317), complex(0.641952,0.786288), complex(0.896467,0.968191), complex(0.998871,0.987688), complex(0.935583,0.845169), complex(0.720581,0.567269), complex(0.391735,0.201249), complex(0.003534,-0.193549), complex(-0.382321,-0.555570), complex(-0.706829,-0.830596), complex(-0.922521,-0.979540), complex(-0.999952,-0.983445), complex(-0.931072,-0.845169), complex(-0.729237,-0.587785), complex(-0.426135,-0.250211), complex(-0.066317,0.119097), complex(0.299665,0.469317), complex(0.622480,0.754251), complex(0.860542,0.938191), complex(0.985042,0.999980), complex(0.982943,0.934888), complex(0.857729,0.754251), complex(0.627997,0.483130), complex(0.324289,0.156434), complex(-0.015315,-0.185838), complex(-0.350167,-0.503623), complex(-0.641952,-0.761425), complex(-0.858938,-0.932071), complex(-0.979143,-0.999229), complex(-0.992164,-0.958522), complex(-0.899577,-0.817245), complex(-0.714015,-0.592857), complex(-0.457137,-0.310511), complex(-0.156822,0.000000), complex(0.156047,0.307523), complex(0.450839,0.582690), complex(0.700131,0.800627), complex(0.882106,0.942991), complex(0.982214,0.999229), complex(0.994004,0.967001), complex(0.919153,0.851818), complex(0.766745,0.666012), complex(0.551973,0.427200), complex(0.294416,0.156434), complex(0.016100,-0.123775), complex(-0.260462,-0.391374), complex(-0.514103,-0.626468), complex(-0.726545,-0.812694), complex(-0.883582,-0.938191), complex(-0.975831,-0.996134), complex(-0.999050,-0.984838), complex(-0.954044,-0.907484), complex(-0.846216,-0.771514), complex(-0.684833,-0.587785), complex(-0.482098,-0.369585), complex(-0.252112,-0.131564), complex(-0.009817,0.111295), complex(0.230007,0.344643), complex(0.453641,0.555570), complex(0.649149,0.733255), complex(0.806935,0.869409), complex(0.920078,0.958522), complex(0.984496,0.997927), complex(0.998908,0.987688), complex(0.964661,0.930354), complex(0.885414,0.830596), complex(0.766745,0.694784), complex(0.615696,0.530511), complex(0.440292,0.346117), complex(0.249070,0.150226), complex(0.050637,-0.048675), complex(-0.146730,-0.242599), complex(-0.335410,-0.424357), complex(-0.508703,-0.587785), complex(-0.661017,-0.727892), complex(-0.787984,-0.840945), complex(-0.886507,-0.924480), complex(-0.954748,-0.977268), complex(-0.992065,-0.999229), complex(-0.998908,-0.991308), complex(-0.976682,-0.955330), complex(-0.927592,-0.893841), complex(-0.854481,-0.809939), complex(-0.760661,-0.707107), complex(-0.649747,-0.589055), complex(-0.525509,-0.459580), complex(-0.391735,-0.322431), complex(-0.252112,-0.181206), complex(-0.110125,-0.039260), complex(0.031018,0.100362), complex(0.168446,0.234972), complex(0.299665,0.362275), complex(0.422579,0.480377), complex(0.535495,0.587785), complex(0.637121,0.683401), complex(0.726545,0.766493), complex(0.803208,0.836669), complex(0.866875,0.893841), complex(0.917599,0.938191), complex(0.955677,0.970127), complex(0.981619,0.990244), complex(0.996099,0.999289), complex(0.999926,0.998124), complex(0.994004,0.987688), complex(0.979302,0.968973), complex(0.956826,0.942991), complex(0.927592,0.910756), complex(0.892605,0.873262), complex(0.852845,0.831470), complex(0.809248,0.786288), complex(0.762697,0.738573), complex(0.714015,0.689114), complex(0.663959,0.638634), complex(0.613217,0.587785), complex(0.562408,0.537152), complex(0.512080,0.487250), complex(0.462716,0.438528), complex(0.414733,0.391374), complex(0.368490,0.346117), complex(0.324289,0.303035), complex(0.282383,0.262358), complex(0.242980,0.224271), complex(0.206247,0.188924), complex(0.172316,0.156434), complex(0.141290,0.126891), complex(0.113247,0.100362), complex(0.088242,0.076893), complex(0.066317,0.056519), complex(0.047499,0.039260), complex(0.031803,0.025130), complex(0.019241,0.014137), complex(0.009817,0.006283), complex(0.003534,0.001571), complex(0.000393,0.000000), complex(0.000393,0.001571), complex(0.003534,0.006283), complex(0.009817,0.014137), complex(0.019241,0.025130), complex(0.031803,0.039260), complex(0.047499,0.056519), complex(0.066317,0.076893), complex(0.088242,0.100362), complex(0.113247,0.126891), complex(0.141290,0.156434), complex(0.172316,0.188924), complex(0.206247,0.224271), complex(0.242980,0.262358), complex(0.282383,0.303035), complex(0.324289,0.346117), complex(0.368490,0.391374), complex(0.414733,0.438528), complex(0.462716,0.487250), complex(0.512080,0.537152), complex(0.562408,0.587785), complex(0.613217,0.638634), complex(0.663959,0.689114), complex(0.714015,0.738573), complex(0.762697,0.786288), complex(0.809248,0.831470), complex(0.852845,0.873262), complex(0.892605,0.910756), complex(0.927592,0.942991), complex(0.956826,0.968973), complex(0.979302,0.987688), complex(0.994004,0.998124), complex(0.999926,0.999289), complex(0.996099,0.990244), complex(0.981619,0.970127), complex(0.955677,0.938191), complex(0.917599,0.893841), complex(0.866875,0.836669), complex(0.803208,0.766493), complex(0.726545,0.683401), complex(0.637121,0.587785), complex(0.535495,0.480377), complex(0.422579,0.362275), complex(0.299665,0.234972), complex(0.168446,0.100362), complex(0.031018,-0.039260), complex(-0.110125,-0.181206), complex(-0.252112,-0.322431), complex(-0.391735,-0.459580), complex(-0.525509,-0.589055), complex(-0.649747,-0.707107), complex(-0.760661,-0.809939), complex(-0.854481,-0.893841), complex(-0.927592,-0.955330), complex(-0.976682,-0.991308), complex(-0.998908,-0.999229), complex(-0.992065,-0.977268), complex(-0.954748,-0.924480), complex(-0.886507,-0.840945), complex(-0.787984,-0.727892), complex(-0.661017,-0.587785), complex(-0.508703,-0.424357), complex(-0.335410,-0.242599), complex(-0.146730,-0.048675), complex(0.050637,0.150226), complex(0.249070,0.346117), complex(0.440292,0.530511), complex(0.615696,0.694784), complex(0.766745,0.830596), complex(0.885414,0.930354), complex(0.964661,0.987688), complex(0.998908,0.997927), complex(0.984496,0.958522), complex(0.920078,0.869409), complex(0.806935,0.733255), complex(0.649149,0.555570), complex(0.453641,0.344643), complex(0.230007,0.111295), complex(-0.009817,-0.131564), complex(-0.252112,-0.369585), complex(-0.482098,-0.587785), complex(-0.684833,-0.771514), complex(-0.846216,-0.907484), complex(-0.954044,-0.984838), complex(-0.999050,-0.996134), complex(-0.975831,-0.938191), complex(-0.883582,-0.812694), complex(-0.726545,-0.626468), complex(-0.514103,-0.391374), complex(-0.260462,-0.123775), complex(0.016100,0.156434), complex(0.294416,0.427200), complex(0.551973,0.666012), complex(0.766745,0.851818), complex(0.919153,0.967001), complex(0.994004,0.999229), complex(0.982214,0.942991), complex(0.882106,0.800627), complex(0.700131,0.582690), complex(0.450839,0.307523), complex(0.156047,0.000000), complex(-0.156822,-0.310511), complex(-0.457137,-0.592857), complex(-0.714015,-0.817245), complex(-0.899577,-0.958522), complex(-0.992164,-0.999229), complex(-0.979143,-0.932071), complex(-0.858938,-0.761425), complex(-0.641952,-0.503623), complex(-0.350167,-0.185838), complex(-0.015315,0.156434), complex(0.324289,0.483130), complex(0.627997,0.754251), complex(0.857729,0.934888), complex(0.982943,0.999980), complex(0.985042,0.938191), complex(0.860542,0.754251), complex(0.622480,0.469317), complex(0.299665,0.119097), complex(-0.066317,-0.250211), complex(-0.426135,-0.587785), complex(-0.729237,-0.845169), complex(-0.931072,-0.983445), complex(-0.999952,-0.979540), complex(-0.922521,-0.830596), complex(-0.706829,-0.555570), complex(-0.382321,-0.193549), complex(0.003534,0.201249), complex(0.391735,0.567269), complex(0.720581,0.845169), complex(0.935583,0.987688), complex(0.998871,0.968191), complex(0.896467,0.786288), complex(0.641952,0.469317), complex(0.275595,0.069060), complex(-0.141290,-0.346117), complex(-0.536158,-0.702650), complex(-0.837743,-0.934888), complex(-0.989177,-0.997613), complex(-0.959302,-0.875549), complex(-0.749851,-0.587785), complex(-0.396787,-0.185838), complex(0.034943,0.254771), complex(0.462716,0.648253), complex(0.801802,0.915241), complex(0.982361,0.999229), complex(0.964454,0.879316), complex(0.747769,0.576290), complex(0.373595,0.150226), complex(-0.081982,-0.310511), complex(-0.522833,-0.707107), complex(-0.852845,-0.951541), complex(-0.997188,-0.986686), complex(-0.920078,-0.800627), complex(-0.634697,-0.431456), complex(-0.202403,0.039260), complex(0.279368,0.503623), complex(0.698447,0.851818), complex(0.954044,0.998402), complex(0.981619,0.904157), complex(0.770263,0.587785), complex(0.367759,0.123775), complex(-0.128839,-0.373959), complex(-0.595699,-0.779447), complex(-0.912852,-0.986686), complex(-0.995525,-0.938191), complex(-0.817924,-0.642253), complex(-0.422579,-0.173476), complex(0.088242,0.344643), complex(0.577893,0.771514), complex(0.911565,0.987688), complex(0.993918,0.929197), complex(0.797558,0.607930), complex(0.373595,0.111295), complex(-0.159924,-0.420086), complex(-0.649747,-0.831470), complex(-0.951178,-0.999289), complex(-0.971539,-0.869409), complex(-0.700131,-0.476238), complex(-0.214693,0.064358), complex(0.339107,0.587785), complex(0.790396,0.930354), complex(0.995888,0.981091), complex(0.886507,0.719219), complex(0.492386,0.224271), complex(-0.063182,-0.346117), complex(-0.600734,-0.805308), complex(-0.942072,-0.998815), complex(-0.970031,-0.857527), complex(-0.670394,-0.424357), complex(-0.140512,0.156434), complex(0.440292,0.685691), complex(0.870377,0.977268), complex(0.996099,0.924480), complex(0.768256,0.541121), complex(0.263494,-0.039260), complex(-0.339107,-0.607930), complex(-0.820177,-0.955330), complex(-0.999952,-0.949096), complex(-0.806935,-0.586514), complex(-0.308643,0.000000))
    option1: (complex(1.000000,0.951178), complex(0.809939,0.590641), complex(0.314987,0.009817), complex(-0.295541,-0.572110), complex(-0.793990,-0.940748), complex(-0.999229,-0.964661), complex(-0.840945,-0.640143), complex(-0.381232,-0.088242), complex(0.212007,0.492386), complex(0.727892,0.897855), complex(0.987688,0.990079), complex(0.905495,0.742005), complex(0.514440,0.242980), complex(-0.048675,-0.335410), complex(-0.592857,-0.799449), complex(-0.938191,-0.998002), complex(-0.974527,-0.870377), complex(-0.694784,-0.462716), complex(-0.193549,0.090589), complex(0.366664,0.612597), complex(0.809017,0.940748), complex(0.997927,0.976682), complex(0.879316,0.714015), complex(0.494094,0.236881), complex(-0.037690,-0.308643), complex(-0.555570,-0.760151), complex(-0.907484,-0.987129), complex(-0.993787,-0.927592), complex(-0.793990,-0.603243), complex(-0.369585,-0.110125), complex(0.156434,0.411156), complex(0.636213,0.816112), complex(0.938734,0.996099), complex(0.984838,0.906326), complex(0.766493,0.575326), complex(0.346117,0.094499), complex(-0.162637,-0.408291), complex(-0.626468,-0.803208), complex(-0.927445,-0.991666), complex(-0.992310,-0.929921), complex(-0.809017,-0.637727), complex(-0.427200,-0.190852), complex(0.056519,0.299665), complex(0.523837,0.715662), complex(0.863923,0.960184), complex(0.999229,0.979302), complex(0.902134,0.772761), complex(0.599163,0.391735), complex(0.162637,-0.074935), complex(-0.307523,-0.522164), complex(-0.707107,-0.852435), complex(-0.950570,-0.996634), complex(-0.988652,-0.927592), complex(-0.817245,-0.663959), complex(-0.476238,-0.264252), complex(-0.039260,0.186996), complex(0.402906,0.597590), complex(0.761425,0.886507), complex(0.967001,0.999389), complex(0.982580,0.917911), complex(0.809017,0.661606), complex(0.483130,0.282383), complex(0.069060,-0.146730), complex(-0.354944,-0.546065), complex(-0.711536,-0.844117), complex(-0.938191,-0.989968), complex(-0.997613,-0.961274), complex(-0.883030,-0.766745), complex(-0.617860,-0.443110), complex(-0.250211,-0.047499), complex(0.156434,0.353107), complex(0.534500,0.693370), complex(0.823533,0.920078), complex(0.979540,0.999994), complex(0.981091,0.924030), complex(0.831470,0.707384), complex(0.556876,0.385946), complex(0.201249,0.009817), complex(-0.181206,-0.364836), complex(-0.534500,-0.684261), complex(-0.809017,-0.904660), complex(-0.968191,-0.997799), complex(-0.992883,-0.954044), complex(-0.883030,-0.782635), complex(-0.656586,-0.509379), complex(-0.346117,-0.172316), complex(0.006283,0.183908), complex(0.354944,0.514103), complex(0.656586,0.778216), complex(0.875549,0.945958), complex(0.987688,0.999883), complex(0.982580,0.936687), complex(0.863923,0.766745), complex(0.648253,0.512080), complex(0.362275,0.203172), complex(0.039260,-0.124944), complex(-0.285019,-0.436763), complex(-0.576290,-0.700131), complex(-0.805308,-0.889396), complex(-0.950570,-0.987627), complex(-1.000000,-0.987750), complex(-0.951541,-0.892605), complex(-0.812694,-0.714015), complex(-0.599163,-0.471050), complex(-0.332820,-0.187767), complex(-0.039260,0.109344), complex(0.254771,0.393902), complex(0.523837,0.641952), complex(0.745941,0.833862), complex(0.904157,0.955677), complex(0.987688,0.999870), complex(0.992310,0.965484), complex(0.920232,0.857729), complex(0.779447,0.687119), complex(0.582690,0.468277), complex(0.346117,0.218526), complex(0.087851,-0.043576), complex(-0.173476,-0.299665), complex(-0.420086,-0.532839), complex(-0.636213,-0.728700), complex(-0.809017,-0.876117), complex(-0.929197,-0.967698), complex(-0.991308,-0.999952), complex(-0.993787,-0.973189), complex(-0.938734,-0.891185), complex(-0.831470,-0.760661), complex(-0.679953,-0.590641), complex(-0.494094,-0.391735), complex(-0.285019,-0.175410), complex(-0.064358,0.046714), complex(0.156434,0.263494), complex(0.366664,0.464803), complex(0.556876,0.641952), complex(0.719219,0.787984), complex(0.847678,0.897855), complex(0.938191,0.968485), complex(0.988652,0.998717), complex(0.998815,0.989177), complex(0.970127,0.942072), complex(0.905495,0.860942), complex(0.809017,0.750371), complex(0.685691,0.615696), complex(0.541121,0.462716), complex(0.381232,0.297417), complex(0.212007,0.125723), complex(0.039260,-0.046714), complex(-0.131564,-0.214693), complex(-0.295541,-0.373595), complex(-0.448383,-0.519482), complex(-0.586514,-0.649149), complex(-0.707107,-0.760151), complex(-0.808093,-0.850788), complex(-0.888136,-0.920078), complex(-0.946593,-0.967698), complex(-0.983445,-0.993918), complex(-0.999229,-0.999519), complex(-0.994951,-0.985711), complex(-0.972002,-0.954044), complex(-0.932071,-0.906326), complex(-0.877062,-0.844538), complex(-0.809017,-0.770763), complex(-0.730043,-0.687119), complex(-0.642253,-0.595699), complex(-0.547709,-0.498526), complex(-0.448383,-0.397508), complex(-0.346117,-0.294416), complex(-0.242599,-0.190852), complex(-0.139346,-0.088242), complex(-0.037690,0.012173), complex(0.061223,0.109344), complex(0.156434,0.202403), complex(0.247168,0.290660), complex(0.332820,0.373595), complex(0.412945,0.450839), complex(0.487250,0.522164), complex(0.555570,0.587468), complex(0.617860,0.646757), complex(0.674173,0.700131), complex(0.724653,0.747769), complex(0.769511,0.789914), complex(0.809017,0.826860), complex(0.843485,0.858938), complex(0.873262,0.886507), complex(0.898718,0.909943), complex(0.920232,0.929632), complex(0.938191,0.945958), complex(0.952979,0.959302), complex(0.964971,0.970031), complex(0.974527,0.978500), complex(0.981992,0.985042), complex(0.987688,0.989968), complex(0.991917,0.993567), complex(0.994951,0.996099), complex(0.997039,0.997799), complex(0.998402,0.998871), complex(0.999229,0.999494), complex(0.999684,0.999815), complex(0.999900,0.999952), complex(0.999980,0.999994), complex(0.999999,1.000000), complex(1.000000,1.000000), complex(0.999999,0.999994), complex(0.999980,0.999952), complex(0.999900,0.999815), complex(0.999684,0.999494), complex(0.999229,0.998871), complex(0.998402,0.997799), complex(0.997039,0.996099), complex(0.994951,0.993567), complex(0.991917,0.989968), complex(0.987688,0.985042), complex(0.981992,0.978500), complex(0.974527,0.970031), complex(0.964971,0.959302), complex(0.952979,0.945958), complex(0.938191,0.929632), complex(0.920232,0.909943), complex(0.898718,0.886507), complex(0.873262,0.858938), complex(0.843485,0.826860), complex(0.809017,0.789914), complex(0.769511,0.747769), complex(0.724653,0.700131), complex(0.674173,0.646757), complex(0.617860,0.587468), complex(0.555570,0.522164), complex(0.487250,0.450839), complex(0.412945,0.373595), complex(0.332820,0.290660), complex(0.247168,0.202403), complex(0.156434,0.109344), complex(0.061223,0.012173), complex(-0.037690,-0.088242), complex(-0.139346,-0.190852), complex(-0.242599,-0.294416), complex(-0.346117,-0.397508), complex(-0.448383,-0.498526), complex(-0.547709,-0.595699), complex(-0.642253,-0.687119), complex(-0.730043,-0.770763), complex(-0.809017,-0.844538), complex(-0.877062,-0.906326), complex(-0.932071,-0.954044), complex(-0.972002,-0.985711), complex(-0.994951,-0.999519), complex(-0.999229,-0.993918), complex(-0.983445,-0.967698), complex(-0.946593,-0.920078), complex(-0.888136,-0.850788), complex(-0.808093,-0.760151), complex(-0.707107,-0.649149), complex(-0.586514,-0.519482), complex(-0.448383,-0.373595), complex(-0.295541,-0.214693), complex(-0.131564,-0.046714), complex(0.039260,0.125723), complex(0.212007,0.297417), complex(0.381232,0.462716), complex(0.541121,0.615696), complex(0.685691,0.750371), complex(0.809017,0.860942), complex(0.905495,0.942072), complex(0.970127,0.989177), complex(0.998815,0.998717), complex(0.988652,0.968485), complex(0.938191,0.897855), complex(0.847678,0.787984), complex(0.719219,0.641952), complex(0.556876,0.464803), complex(0.366664,0.263494), complex(0.156434,0.046714), complex(-0.064358,-0.175410), complex(-0.285019,-0.391735), complex(-0.494094,-0.590641), complex(-0.679953,-0.760661), complex(-0.831470,-0.891185), complex(-0.938734,-0.973189), complex(-0.993787,-0.999952), complex(-0.991308,-0.967698), complex(-0.929197,-0.876117), complex(-0.809017,-0.728700), complex(-0.636213,-0.532839), complex(-0.420086,-0.299665), complex(-0.173476,-0.043576), complex(0.087851,0.218526), complex(0.346117,0.468277), complex(0.582690,0.687119), complex(0.779447,0.857729), complex(0.920232,0.965484), complex(0.992310,0.999870), complex(0.987688,0.955677), complex(0.904157,0.833862), complex(0.745941,0.641952), complex(0.523837,0.393902), complex(0.254771,0.109344), complex(-0.039260,-0.187767), complex(-0.332820,-0.471050), complex(-0.599163,-0.714015), complex(-0.812694,-0.892605), complex(-0.951541,-0.987750), complex(-1.000000,-0.987627), complex(-0.950570,-0.889396), complex(-0.805308,-0.700131), complex(-0.576290,-0.436763), complex(-0.285019,-0.124944), complex(0.039260,0.203172), complex(0.362275,0.512080), complex(0.648253,0.766745), complex(0.863923,0.936687), complex(0.982580,0.999883), complex(0.987688,0.945958), complex(0.875549,0.778216), complex(0.656586,0.514103), complex(0.354944,0.183908), complex(0.006283,-0.172316), complex(-0.346117,-0.509379), complex(-0.656586,-0.782635), complex(-0.883030,-0.954044), complex(-0.992883,-0.997799), complex(-0.968191,-0.904660), complex(-0.809017,-0.684261), complex(-0.534500,-0.364836), complex(-0.181206,0.009817), complex(0.201249,0.385946), complex(0.556876,0.707384), complex(0.831470,0.924030), complex(0.981091,0.999994), complex(0.979540,0.920078), complex(0.823533,0.693370), complex(0.534500,0.353107), complex(0.156434,-0.047499), complex(-0.250211,-0.443110), complex(-0.617860,-0.766745), complex(-0.883030,-0.961274), complex(-0.997613,-0.989968), complex(-0.938191,-0.844117), complex(-0.711536,-0.546065), complex(-0.354944,-0.146730), complex(0.069060,0.282383), complex(0.483130,0.661606), complex(0.809017,0.917911), complex(0.982580,0.999389), complex(0.967001,0.886507), complex(0.761425,0.597590), complex(0.402906,0.186996), complex(-0.039260,-0.264252), complex(-0.476238,-0.663959), complex(-0.817245,-0.927592), complex(-0.988652,-0.996634), complex(-0.950570,-0.852435), complex(-0.707107,-0.522164), complex(-0.307523,-0.074935), complex(0.162637,0.391735), complex(0.599163,0.772761), complex(0.902134,0.979302), complex(0.999229,0.960184), complex(0.863923,0.715662), complex(0.523837,0.299665), complex(0.056519,-0.190852), complex(-0.427200,-0.637727), complex(-0.809017,-0.929921), complex(-0.992310,-0.991666), complex(-0.927445,-0.803208), complex(-0.626468,-0.408291), complex(-0.162637,0.094499), complex(0.346117,0.575326), complex(0.766493,0.906326), complex(0.984838,0.996099), complex(0.938734,0.816112), complex(0.636213,0.411156), complex(0.156434,-0.110125), complex(-0.369585,-0.603243), complex(-0.793990,-0.927592), complex(-0.993787,-0.987129), complex(-0.907484,-0.760151), complex(-0.555570,-0.308643), complex(-0.037690,0.236881), complex(0.494094,0.714015), complex(0.879316,0.976682), complex(0.997927,0.940748), complex(0.809017,0.612597), complex(0.366664,0.090589), complex(-0.193549,-0.462716), complex(-0.694784,-0.870377), complex(-0.974527,-0.998002), complex(-0.938191,-0.799449), complex(-0.592857,-0.335410), complex(-0.048675,0.242980), complex(0.514440,0.742005), complex(0.905495,0.990079), complex(0.987688,0.897855), complex(0.727892,0.492386), complex(0.212007,-0.088242), complex(-0.381232,-0.640143), complex(-0.840945,-0.964661), complex(-0.999229,-0.940748), complex(-0.793990,-0.572110), complex(-0.295541,0.009817), complex(0.314987,0.590641), complex(0.809939,0.951178), complex(1.000000,0.000000), complex(0.308643,0.586514), complex(0.806935,0.949096), complex(0.999952,0.955330), complex(0.820177,0.607930), complex(0.339107,0.039260), complex(-0.263494,-0.541121), complex(-0.768256,-0.924480), complex(-0.996099,-0.977268), complex(-0.870377,-0.685691), complex(-0.440292,-0.156434), complex(0.140512,0.424357), complex(0.670394,0.857527), complex(0.970031,0.998815), complex(0.942072,0.805308), complex(0.600734,0.346117), complex(0.063182,-0.224271), complex(-0.492386,-0.719219), complex(-0.886507,-0.981091), complex(-0.995888,-0.930354), complex(-0.790396,-0.587785), complex(-0.339107,-0.064358), complex(0.214693,0.476238), complex(0.700131,0.869409), complex(0.971539,0.999289), complex(0.951178,0.831470), complex(0.649747,0.420086), complex(0.159924,-0.111295), complex(-0.373595,-0.607930), complex(-0.797558,-0.929197), complex(-0.993918,-0.987688), complex(-0.911565,-0.771514), complex(-0.577893,-0.344643), complex(-0.088242,0.173476), complex(0.422579,0.642253), complex(0.817924,0.938191), complex(0.995525,0.986686), complex(0.912852,0.779447), complex(0.595699,0.373959), complex(0.128839,-0.123775), complex(-0.367759,-0.587785), complex(-0.770263,-0.904157), complex(-0.981619,-0.998402), complex(-0.954044,-0.851818), complex(-0.698447,-0.503623), complex(-0.279368,-0.039260), complex(0.202403,0.431456), complex(0.634697,0.800627), complex(0.920078,0.986686), complex(0.997188,0.951541), complex(0.852845,0.707107), complex(0.522833,0.310511), complex(0.081982,-0.150226), complex(-0.373595,-0.576290), complex(-0.747769,-0.879316), complex(-0.964454,-0.999229), complex(-0.982361,-0.915241), complex(-0.801802,-0.648253), complex(-0.462716,-0.254771), complex(-0.034943,0.185838), complex(0.396787,0.587785), complex(0.749851,0.875549), complex(0.959302,0.997613), complex(0.989177,0.934888), complex(0.837743,0.702650), complex(0.536158,0.346117), complex(0.141290,-0.069060), complex(-0.275595,-0.469317), complex(-0.641952,-0.786288), complex(-0.896467,-0.968191), complex(-0.998871,-0.987688), complex(-0.935583,-0.845169), complex(-0.720581,-0.567269), complex(-0.391735,-0.201249), complex(-0.003534,0.193549), complex(0.382321,0.555570), complex(0.706829,0.830596), complex(0.922521,0.979540), complex(0.999952,0.983445), complex(0.931072,0.845169), complex(0.729237,0.587785), complex(0.426135,0.250211), complex(0.066317,-0.119097), complex(-0.299665,-0.469317), complex(-0.622480,-0.754251), complex(-0.860542,-0.938191), complex(-0.985042,-0.999980), complex(-0.982943,-0.934888), complex(-0.857729,-0.754251), complex(-0.627997,-0.483130), complex(-0.324289,-0.156434), complex(0.015315,0.185838), complex(0.350167,0.503623), complex(0.641952,0.761425), complex(0.858938,0.932071), complex(0.979143,0.999229), complex(0.992164,0.958522), complex(0.899577,0.817245), complex(0.714015,0.592857), complex(0.457137,0.310511), complex(0.156822,-0.000000), complex(-0.156047,-0.307523), complex(-0.450839,-0.582690), complex(-0.700131,-0.800627), complex(-0.882106,-0.942991), complex(-0.982214,-0.999229), complex(-0.994004,-0.967001), complex(-0.919153,-0.851818), complex(-0.766745,-0.666012), complex(-0.551973,-0.427200), complex(-0.294416,-0.156434), complex(-0.016100,0.123775), complex(0.260462,0.391374), complex(0.514103,0.626468), complex(0.726545,0.812694), complex(0.883582,0.938191), complex(0.975831,0.996134), complex(0.999050,0.984838), complex(0.954044,0.907484), complex(0.846216,0.771514), complex(0.684833,0.587785), complex(0.482098,0.369585), complex(0.252112,0.131564), complex(0.009817,-0.111295), complex(-0.230007,-0.344643), complex(-0.453641,-0.555570), complex(-0.649149,-0.733255), complex(-0.806935,-0.869409), complex(-0.920078,-0.958522), complex(-0.984496,-0.997927), complex(-0.998908,-0.987688), complex(-0.964661,-0.930354), complex(-0.885414,-0.830596), complex(-0.766745,-0.694784), complex(-0.615696,-0.530511), complex(-0.440292,-0.346117), complex(-0.249070,-0.150226), complex(-0.050637,0.048675), complex(0.146730,0.242599), complex(0.335410,0.424357), complex(0.508703,0.587785), complex(0.661017,0.727892), complex(0.787984,0.840945), complex(0.886507,0.924480), complex(0.954748,0.977268), complex(0.992065,0.999229), complex(0.998908,0.991308), complex(0.976682,0.955330), complex(0.927592,0.893841), complex(0.854481,0.809939), complex(0.760661,0.707107), complex(0.649747,0.589055), complex(0.525509,0.459580), complex(0.391735,0.322431), complex(0.252112,0.181206), complex(0.110125,0.039260), complex(-0.031018,-0.100362), complex(-0.168446,-0.234972), complex(-0.299665,-0.362275), complex(-0.422579,-0.480377), complex(-0.535495,-0.587785), complex(-0.637121,-0.683401), complex(-0.726545,-0.766493), complex(-0.803208,-0.836669), complex(-0.866875,-0.893841), complex(-0.917599,-0.938191), complex(-0.955677,-0.970127), complex(-0.981619,-0.990244), complex(-0.996099,-0.999289), complex(-0.999926,-0.998124), complex(-0.994004,-0.987688), complex(-0.979302,-0.968973), complex(-0.956826,-0.942991), complex(-0.927592,-0.910756), complex(-0.892605,-0.873262), complex(-0.852845,-0.831470), complex(-0.809248,-0.786288), complex(-0.762697,-0.738573), complex(-0.714015,-0.689114), complex(-0.663959,-0.638634), complex(-0.613217,-0.587785), complex(-0.562408,-0.537152), complex(-0.512080,-0.487250), complex(-0.462716,-0.438528), complex(-0.414733,-0.391374), complex(-0.368490,-0.346117), complex(-0.324289,-0.303035), complex(-0.282383,-0.262358), complex(-0.242980,-0.224271), complex(-0.206247,-0.188924), complex(-0.172316,-0.156434), complex(-0.141290,-0.126891), complex(-0.113247,-0.100362), complex(-0.088242,-0.076893), complex(-0.066317,-0.056519), complex(-0.047499,-0.039260), complex(-0.031803,-0.025130), complex(-0.019241,-0.014137), complex(-0.009817,-0.006283), complex(-0.003534,-0.001571), complex(-0.000393,-0.000000), complex(-0.000393,-0.001571), complex(-0.003534,-0.006283), complex(-0.009817,-0.014137), complex(-0.019241,-0.025130), complex(-0.031803,-0.039260), complex(-0.047499,-0.056519), complex(-0.066317,-0.076893), complex(-0.088242,-0.100362), complex(-0.113247,-0.126891), complex(-0.141290,-0.156434), complex(-0.172316,-0.188924), complex(-0.206247,-0.224271), complex(-0.242980,-0.262358), complex(-0.282383,-0.303035), complex(-0.324289,-0.346117), complex(-0.368490,-0.391374), complex(-0.414733,-0.438528), complex(-0.462716,-0.487250), complex(-0.512080,-0.537152), complex(-0.562408,-0.587785), complex(-0.613217,-0.638634), complex(-0.663959,-0.689114), complex(-0.714015,-0.738573), complex(-0.762697,-0.786288), complex(-0.809248,-0.831470), complex(-0.852845,-0.873262), complex(-0.892605,-0.910756), complex(-0.927592,-0.942991), complex(-0.956826,-0.968973), complex(-0.979302,-0.987688), complex(-0.994004,-0.998124), complex(-0.999926,-0.999289), complex(-0.996099,-0.990244), complex(-0.981619,-0.970127), complex(-0.955677,-0.938191), complex(-0.917599,-0.893841), complex(-0.866875,-0.836669), complex(-0.803208,-0.766493), complex(-0.726545,-0.683401), complex(-0.637121,-0.587785), complex(-0.535495,-0.480377), complex(-0.422579,-0.362275), complex(-0.299665,-0.234972), complex(-0.168446,-0.100362), complex(-0.031018,0.039260), complex(0.110125,0.181206), complex(0.252112,0.322431), complex(0.391735,0.459580), complex(0.525509,0.589055), complex(0.649747,0.707107), complex(0.760661,0.809939), complex(0.854481,0.893841), complex(0.927592,0.955330), complex(0.976682,0.991308), complex(0.998908,0.999229), complex(0.992065,0.977268), complex(0.954748,0.924480), complex(0.886507,0.840945), complex(0.787984,0.727892), complex(0.661017,0.587785), complex(0.508703,0.424357), complex(0.335410,0.242599), complex(0.146730,0.048675), complex(-0.050637,-0.150226), complex(-0.249070,-0.346117), complex(-0.440292,-0.530511), complex(-0.615696,-0.694784), complex(-0.766745,-0.830596), complex(-0.885414,-0.930354), complex(-0.964661,-0.987688), complex(-0.998908,-0.997927), complex(-0.984496,-0.958522), complex(-0.920078,-0.869409), complex(-0.806935,-0.733255), complex(-0.649149,-0.555570), complex(-0.453641,-0.344643), complex(-0.230007,-0.111295), complex(0.009817,0.131564), complex(0.252112,0.369585), complex(0.482098,0.587785), complex(0.684833,0.771514), complex(0.846216,0.907484), complex(0.954044,0.984838), complex(0.999050,0.996134), complex(0.975831,0.938191), complex(0.883582,0.812694), complex(0.726545,0.626468), complex(0.514103,0.391374), complex(0.260462,0.123775), complex(-0.016100,-0.156434), complex(-0.294416,-0.427200), complex(-0.551973,-0.666012), complex(-0.766745,-0.851818), complex(-0.919153,-0.967001), complex(-0.994004,-0.999229), complex(-0.982214,-0.942991), complex(-0.882106,-0.800627), complex(-0.700131,-0.582690), complex(-0.450839,-0.307523), complex(-0.156047,-0.000000), complex(0.156822,0.310511), complex(0.457137,0.592857), complex(0.714015,0.817245), complex(0.899577,0.958522), complex(0.992164,0.999229), complex(0.979143,0.932071), complex(0.858938,0.761425), complex(0.641952,0.503623), complex(0.350167,0.185838), complex(0.015315,-0.156434), complex(-0.324289,-0.483130), complex(-0.627997,-0.754251), complex(-0.857729,-0.934888), complex(-0.982943,-0.999980), complex(-0.985042,-0.938191), complex(-0.860542,-0.754251), complex(-0.622480,-0.469317), complex(-0.299665,-0.119097), complex(0.066317,0.250211), complex(0.426135,0.587785), complex(0.729237,0.845169), complex(0.931072,0.983445), complex(0.999952,0.979540), complex(0.922521,0.830596), complex(0.706829,0.555570), complex(0.382321,0.193549), complex(-0.003534,-0.201249), complex(-0.391735,-0.567269), complex(-0.720581,-0.845169), complex(-0.935583,-0.987688), complex(-0.998871,-0.968191), complex(-0.896467,-0.786288), complex(-0.641952,-0.469317), complex(-0.275595,-0.069060), complex(0.141290,0.346117), complex(0.536158,0.702650), complex(0.837743,0.934888), complex(0.989177,0.997613), complex(0.959302,0.875549), complex(0.749851,0.587785), complex(0.396787,0.185838), complex(-0.034943,-0.254771), complex(-0.462716,-0.648253), complex(-0.801802,-0.915241), complex(-0.982361,-0.999229), complex(-0.964454,-0.879316), complex(-0.747769,-0.576290), complex(-0.373595,-0.150226), complex(0.081982,0.310511), complex(0.522833,0.707107), complex(0.852845,0.951541), complex(0.997188,0.986686), complex(0.920078,0.800627), complex(0.634697,0.431456), complex(0.202403,-0.039260), complex(-0.279368,-0.503623), complex(-0.698447,-0.851818), complex(-0.954044,-0.998402), complex(-0.981619,-0.904157), complex(-0.770263,-0.587785), complex(-0.367759,-0.123775), complex(0.128839,0.373959), complex(0.595699,0.779447), complex(0.912852,0.986686), complex(0.995525,0.938191), complex(0.817924,0.642253), complex(0.422579,0.173476), complex(-0.088242,-0.344643), complex(-0.577893,-0.771514), complex(-0.911565,-0.987688), complex(-0.993918,-0.929197), complex(-0.797558,-0.607930), complex(-0.373595,-0.111295), complex(0.159924,0.420086), complex(0.649747,0.831470), complex(0.951178,0.999289), complex(0.971539,0.869409), complex(0.700131,0.476238), complex(0.214693,-0.064358), complex(-0.339107,-0.587785), complex(-0.790396,-0.930354), complex(-0.995888,-0.981091), complex(-0.886507,-0.719219), complex(-0.492386,-0.224271), complex(0.063182,0.346117), complex(0.600734,0.805308), complex(0.942072,0.998815), complex(0.970031,0.857527), complex(0.670394,0.424357), complex(0.140512,-0.156434), complex(-0.440292,-0.685691), complex(-0.870377,-0.977268), complex(-0.996099,-0.924480), complex(-0.768256,-0.541121), complex(-0.263494,0.039260), complex(0.339107,0.607930), complex(0.820177,0.955330), complex(0.999952,0.949096), complex(0.806935,0.586514), complex(0.308643,0.000000), )
    type: raw
    value: (complex(1.000000,0.951178), complex(0.809939,0.590641), complex(0.314987,0.009817), complex(-0.295541,-0.572110), complex(-0.793990,-0.940748), complex(-0.999229,-0.964661), complex(-0.840945,-0.640143), complex(-0.381232,-0.088242), complex(0.212007,0.492386), complex(0.727892,0.897855), complex(0.987688,0.990079), complex(0.905495,0.742005), complex(0.514440,0.242980), complex(-0.048675,-0.335410), complex(-0.592857,-0.799449), complex(-0.938191,-0.998002), complex(-0.974527,-0.870377), complex(-0.694784,-0.462716), complex(-0.193549,0.090589), complex(0.366664,0.612597), complex(0.809017,0.940748), complex(0.997927,0.976682), complex(0.879316,0.714015), complex(0.494094,0.236881), complex(-0.037690,-0.308643), complex(-0.555570,-0.760151), complex(-0.907484,-0.987129), complex(-0.993787,-0.927592), complex(-0.793990,-0.603243), complex(-0.369585,-0.110125), complex(0.156434,0.411156), complex(0.636213,0.816112), complex(0.938734,0.996099), complex(0.984838,0.906326), complex(0.766493,0.575326), complex(0.346117,0.094499), complex(-0.162637,-0.408291), complex(-0.626468,-0.803208), complex(-0.927445,-0.991666), complex(-0.992310,-0.929921), complex(-0.809017,-0.637727), complex(-0.427200,-0.190852), complex(0.056519,0.299665), complex(0.523837,0.715662), complex(0.863923,0.960184), complex(0.999229,0.979302), complex(0.902134,0.772761), complex(0.599163,0.391735), complex(0.162637,-0.074935), complex(-0.307523,-0.522164), complex(-0.707107,-0.852435), complex(-0.950570,-0.996634), complex(-0.988652,-0.927592), complex(-0.817245,-0.663959), complex(-0.476238,-0.264252), complex(-0.039260,0.186996), complex(0.402906,0.597590), complex(0.761425,0.886507), complex(0.967001,0.999389), complex(0.982580,0.917911), complex(0.809017,0.661606), complex(0.483130,0.282383), complex(0.069060,-0.146730), complex(-0.354944,-0.546065), complex(-0.711536,-0.844117), complex(-0.938191,-0.989968), complex(-0.997613,-0.961274), complex(-0.883030,-0.766745), complex(-0.617860,-0.443110), complex(-0.250211,-0.047499), complex(0.156434,0.353107), complex(0.534500,0.693370), complex(0.823533,0.920078), complex(0.979540,0.999994), complex(0.981091,0.924030), complex(0.831470,0.707384), complex(0.556876,0.385946), complex(0.201249,0.009817), complex(-0.181206,-0.364836), complex(-0.534500,-0.684261), complex(-0.809017,-0.904660), complex(-0.968191,-0.997799), complex(-0.992883,-0.954044), complex(-0.883030,-0.782635), complex(-0.656586,-0.509379), complex(-0.346117,-0.172316), complex(0.006283,0.183908), complex(0.354944,0.514103), complex(0.656586,0.778216), complex(0.875549,0.945958), complex(0.987688,0.999883), complex(0.982580,0.936687), complex(0.863923,0.766745), complex(0.648253,0.512080), complex(0.362275,0.203172), complex(0.039260,-0.124944), complex(-0.285019,-0.436763), complex(-0.576290,-0.700131), complex(-0.805308,-0.889396), complex(-0.950570,-0.987627), complex(-1.000000,-0.987750), complex(-0.951541,-0.892605), complex(-0.812694,-0.714015), complex(-0.599163,-0.471050), complex(-0.332820,-0.187767), complex(-0.039260,0.109344), complex(0.254771,0.393902), complex(0.523837,0.641952), complex(0.745941,0.833862), complex(0.904157,0.955677), complex(0.987688,0.999870), complex(0.992310,0.965484), complex(0.920232,0.857729), complex(0.779447,0.687119), complex(0.582690,0.468277), complex(0.346117,0.218526), complex(0.087851,-0.043576), complex(-0.173476,-0.299665), complex(-0.420086,-0.532839), complex(-0.636213,-0.728700), complex(-0.809017,-0.876117), complex(-0.929197,-0.967698), complex(-0.991308,-0.999952), complex(-0.993787,-0.973189), complex(-0.938734,-0.891185), complex(-0.831470,-0.760661), complex(-0.679953,-0.590641), complex(-0.494094,-0.391735), complex(-0.285019,-0.175410), complex(-0.064358,0.046714), complex(0.156434,0.263494), complex(0.366664,0.464803), complex(0.556876,0.641952), complex(0.719219,0.787984), complex(0.847678,0.897855), complex(0.938191,0.968485), complex(0.988652,0.998717), complex(0.998815,0.989177), complex(0.970127,0.942072), complex(0.905495,0.860942), complex(0.809017,0.750371), complex(0.685691,0.615696), complex(0.541121,0.462716), complex(0.381232,0.297417), complex(0.212007,0.125723), complex(0.039260,-0.046714), complex(-0.131564,-0.214693), complex(-0.295541,-0.373595), complex(-0.448383,-0.519482), complex(-0.586514,-0.649149), complex(-0.707107,-0.760151), complex(-0.808093,-0.850788), complex(-0.888136,-0.920078), complex(-0.946593,-0.967698), complex(-0.983445,-0.993918), complex(-0.999229,-0.999519), complex(-0.994951,-0.985711), complex(-0.972002,-0.954044), complex(-0.932071,-0.906326), complex(-0.877062,-0.844538), complex(-0.809017,-0.770763), complex(-0.730043,-0.687119), complex(-0.642253,-0.595699), complex(-0.547709,-0.498526), complex(-0.448383,-0.397508), complex(-0.346117,-0.294416), complex(-0.242599,-0.190852), complex(-0.139346,-0.088242), complex(-0.037690,0.012173), complex(0.061223,0.109344), complex(0.156434,0.202403), complex(0.247168,0.290660), complex(0.332820,0.373595), complex(0.412945,0.450839), complex(0.487250,0.522164), complex(0.555570,0.587468), complex(0.617860,0.646757), complex(0.674173,0.700131), complex(0.724653,0.747769), complex(0.769511,0.789914), complex(0.809017,0.826860), complex(0.843485,0.858938), complex(0.873262,0.886507), complex(0.898718,0.909943), complex(0.920232,0.929632), complex(0.938191,0.945958), complex(0.952979,0.959302), complex(0.964971,0.970031), complex(0.974527,0.978500), complex(0.981992,0.985042), complex(0.987688,0.989968), complex(0.991917,0.993567), complex(0.994951,0.996099), complex(0.997039,0.997799), complex(0.998402,0.998871), complex(0.999229,0.999494), complex(0.999684,0.999815), complex(0.999900,0.999952), complex(0.999980,0.999994), complex(0.999999,1.000000), complex(1.000000,1.000000), complex(0.999999,0.999994), complex(0.999980,0.999952), complex(0.999900,0.999815), complex(0.999684,0.999494), complex(0.999229,0.998871), complex(0.998402,0.997799), complex(0.997039,0.996099), complex(0.994951,0.993567), complex(0.991917,0.989968), complex(0.987688,0.985042), complex(0.981992,0.978500), complex(0.974527,0.970031), complex(0.964971,0.959302), complex(0.952979,0.945958), complex(0.938191,0.929632), complex(0.920232,0.909943), complex(0.898718,0.886507), complex(0.873262,0.858938), complex(0.843485,0.826860), complex(0.809017,0.789914), complex(0.769511,0.747769), complex(0.724653,0.700131), complex(0.674173,0.646757), complex(0.617860,0.587468), complex(0.555570,0.522164), complex(0.487250,0.450839), complex(0.412945,0.373595), complex(0.332820,0.290660), complex(0.247168,0.202403), complex(0.156434,0.109344), complex(0.061223,0.012173), complex(-0.037690,-0.088242), complex(-0.139346,-0.190852), complex(-0.242599,-0.294416), complex(-0.346117,-0.397508), complex(-0.448383,-0.498526), complex(-0.547709,-0.595699), complex(-0.642253,-0.687119), complex(-0.730043,-0.770763), complex(-0.809017,-0.844538), complex(-0.877062,-0.906326), complex(-0.932071,-0.954044), complex(-0.972002,-0.985711), complex(-0.994951,-0.999519), complex(-0.999229,-0.993918), complex(-0.983445,-0.967698), complex(-0.946593,-0.920078), complex(-0.888136,-0.850788), complex(-0.808093,-0.760151), complex(-0.707107,-0.649149), complex(-0.586514,-0.519482), complex(-0.448383,-0.373595), complex(-0.295541,-0.214693), complex(-0.131564,-0.046714), complex(0.039260,0.125723), complex(0.212007,0.297417), complex(0.381232,0.462716), complex(0.541121,0.615696), complex(0.685691,0.750371), complex(0.809017,0.860942), complex(0.905495,0.942072), complex(0.970127,0.989177), complex(0.998815,0.998717), complex(0.988652,0.968485), complex(0.938191,0.897855), complex(0.847678,0.787984), complex(0.719219,0.641952), complex(0.556876,0.464803), complex(0.366664,0.263494), complex(0.156434,0.046714), complex(-0.064358,-0.175410), complex(-0.285019,-0.391735), complex(-0.494094,-0.590641), complex(-0.679953,-0.760661), complex(-0.831470,-0.891185), complex(-0.938734,-0.973189), complex(-0.993787,-0.999952), complex(-0.991308,-0.967698), complex(-0.929197,-0.876117), complex(-0.809017,-0.728700), complex(-0.636213,-0.532839), complex(-0.420086,-0.299665), complex(-0.173476,-0.043576), complex(0.087851,0.218526), complex(0.346117,0.468277), complex(0.582690,0.687119), complex(0.779447,0.857729), complex(0.920232,0.965484), complex(0.992310,0.999870), complex(0.987688,0.955677), complex(0.904157,0.833862), complex(0.745941,0.641952), complex(0.523837,0.393902), complex(0.254771,0.109344), complex(-0.039260,-0.187767), complex(-0.332820,-0.471050), complex(-0.599163,-0.714015), complex(-0.812694,-0.892605), complex(-0.951541,-0.987750), complex(-1.000000,-0.987627), complex(-0.950570,-0.889396), complex(-0.805308,-0.700131), complex(-0.576290,-0.436763), complex(-0.285019,-0.124944), complex(0.039260,0.203172), complex(0.362275,0.512080), complex(0.648253,0.766745), complex(0.863923,0.936687), complex(0.982580,0.999883), complex(0.987688,0.945958), complex(0.875549,0.778216), complex(0.656586,0.514103), complex(0.354944,0.183908), complex(0.006283,-0.172316), complex(-0.346117,-0.509379), complex(-0.656586,-0.782635), complex(-0.883030,-0.954044), complex(-0.992883,-0.997799), complex(-0.968191,-0.904660), complex(-0.809017,-0.684261), complex(-0.534500,-0.364836), complex(-0.181206,0.009817), complex(0.201249,0.385946), complex(0.556876,0.707384), complex(0.831470,0.924030), complex(0.981091,0.999994), complex(0.979540,0.920078), complex(0.823533,0.693370), complex(0.534500,0.353107), complex(0.156434,-0.047499), complex(-0.250211,-0.443110), complex(-0.617860,-0.766745), complex(-0.883030,-0.961274), complex(-0.997613,-0.989968), complex(-0.938191,-0.844117), complex(-0.711536,-0.546065), complex(-0.354944,-0.146730), complex(0.069060,0.282383), complex(0.483130,0.661606), complex(0.809017,0.917911), complex(0.982580,0.999389), complex(0.967001,0.886507), complex(0.761425,0.597590), complex(0.402906,0.186996), complex(-0.039260,-0.264252), complex(-0.476238,-0.663959), complex(-0.817245,-0.927592), complex(-0.988652,-0.996634), complex(-0.950570,-0.852435), complex(-0.707107,-0.522164), complex(-0.307523,-0.074935), complex(0.162637,0.391735), complex(0.599163,0.772761), complex(0.902134,0.979302), complex(0.999229,0.960184), complex(0.863923,0.715662), complex(0.523837,0.299665), complex(0.056519,-0.190852), complex(-0.427200,-0.637727), complex(-0.809017,-0.929921), complex(-0.992310,-0.991666), complex(-0.927445,-0.803208), complex(-0.626468,-0.408291), complex(-0.162637,0.094499), complex(0.346117,0.575326), complex(0.766493,0.906326), complex(0.984838,0.996099), complex(0.938734,0.816112), complex(0.636213,0.411156), complex(0.156434,-0.110125), complex(-0.369585,-0.603243), complex(-0.793990,-0.927592), complex(-0.993787,-0.987129), complex(-0.907484,-0.760151), complex(-0.555570,-0.308643), complex(-0.037690,0.236881), complex(0.494094,0.714015), complex(0.879316,0.976682), complex(0.997927,0.940748), complex(0.809017,0.612597), complex(0.366664,0.090589), complex(-0.193549,-0.462716), complex(-0.694784,-0.870377), complex(-0.974527,-0.998002), complex(-0.938191,-0.799449), complex(-0.592857,-0.335410), complex(-0.048675,0.242980), complex(0.514440,0.742005), complex(0.905495,0.990079), complex(0.987688,0.897855), complex(0.727892,0.492386), complex(0.212007,-0.088242), complex(-0.381232,-0.640143), complex(-0.840945,-0.964661), complex(-0.999229,-0.940748), complex(-0.793990,-0.572110), complex(-0.295541,0.009817), complex(0.314987,0.590641), complex(0.809939,0.951178), complex(1.000000,0.000000), complex(-0.308643,-0.586514), complex(-0.806935,-0.949096), complex(-0.999952,-0.955330), complex(-0.820177,-0.607930), complex(-0.339107,-0.039260), complex(0.263494,0.541121), complex(0.768256,0.924480), complex(0.996099,0.977268), complex(0.870377,0.685691), complex(0.440292,0.156434), complex(-0.140512,-0.424357), complex(-0.670394,-0.857527), complex(-0.970031,-0.998815), complex(-0.942072,-0.805308), complex(-0.600734,-0.346117), complex(-0.063182,0.224271), complex(0.492386,0.719219), complex(0.886507,0.981091), complex(0.995888,0.930354), complex(0.790396,0.587785), complex(0.339107,0.064358), complex(-0.214693,-0.476238), complex(-0.700131,-0.869409), complex(-0.971539,-0.999289), complex(-0.951178,-0.831470), complex(-0.649747,-0.420086), complex(-0.159924,0.111295), complex(0.373595,0.607930), complex(0.797558,0.929197), complex(0.993918,0.987688), complex(0.911565,0.771514), complex(0.577893,0.344643), complex(0.088242,-0.173476), complex(-0.422579,-0.642253), complex(-0.817924,-0.938191), complex(-0.995525,-0.986686), complex(-0.912852,-0.779447), complex(-0.595699,-0.373959), complex(-0.128839,0.123775), complex(0.367759,0.587785), complex(0.770263,0.904157), complex(0.981619,0.998402), complex(0.954044,0.851818), complex(0.698447,0.503623), complex(0.279368,0.039260), complex(-0.202403,-0.431456), complex(-0.634697,-0.800627), complex(-0.920078,-0.986686), complex(-0.997188,-0.951541), complex(-0.852845,-0.707107), complex(-0.522833,-0.310511), complex(-0.081982,0.150226), complex(0.373595,0.576290), complex(0.747769,0.879316), complex(0.964454,0.999229), complex(0.982361,0.915241), complex(0.801802,0.648253), complex(0.462716,0.254771), complex(0.034943,-0.185838), complex(-0.396787,-0.587785), complex(-0.749851,-0.875549), complex(-0.959302,-0.997613), complex(-0.989177,-0.934888), complex(-0.837743,-0.702650), complex(-0.536158,-0.346117), complex(-0.141290,0.069060), complex(0.275595,0.469317), complex(0.641952,0.786288), complex(0.896467,0.968191), complex(0.998871,0.987688), complex(0.935583,0.845169), complex(0.720581,0.567269), complex(0.391735,0.201249), complex(0.003534,-0.193549), complex(-0.382321,-0.555570), complex(-0.706829,-0.830596), complex(-0.922521,-0.979540), complex(-0.999952,-0.983445), complex(-0.931072,-0.845169), complex(-0.729237,-0.587785), complex(-0.426135,-0.250211), complex(-0.066317,0.119097), complex(0.299665,0.469317), complex(0.622480,0.754251), complex(0.860542,0.938191), complex(0.985042,0.999980), complex(0.982943,0.934888), complex(0.857729,0.754251), complex(0.627997,0.483130), complex(0.324289,0.156434), complex(-0.015315,-0.185838), complex(-0.350167,-0.503623), complex(-0.641952,-0.761425), complex(-0.858938,-0.932071), complex(-0.979143,-0.999229), complex(-0.992164,-0.958522), complex(-0.899577,-0.817245), complex(-0.714015,-0.592857), complex(-0.457137,-0.310511), complex(-0.156822,0.000000), complex(0.156047,0.307523), complex(0.450839,0.582690), complex(0.700131,0.800627), complex(0.882106,0.942991), complex(0.982214,0.999229), complex(0.994004,0.967001), complex(0.919153,0.851818), complex(0.766745,0.666012), complex(0.551973,0.427200), complex(0.294416,0.156434), complex(0.016100,-0.123775), complex(-0.260462,-0.391374), complex(-0.514103,-0.626468), complex(-0.726545,-0.812694), complex(-0.883582,-0.938191), complex(-0.975831,-0.996134), complex(-0.999050,-0.984838), complex(-0.954044,-0.907484), complex(-0.846216,-0.771514), complex(-0.684833,-0.587785), complex(-0.482098,-0.369585), complex(-0.252112,-0.131564), complex(-0.009817,0.111295), complex(0.230007,0.344643), complex(0.453641,0.555570), complex(0.649149,0.733255), complex(0.806935,0.869409), complex(0.920078,0.958522), complex(0.984496,0.997927), complex(0.998908,0.987688), complex(0.964661,0.930354), complex(0.885414,0.830596), complex(0.766745,0.694784), complex(0.615696,0.530511), complex(0.440292,0.346117), complex(0.249070,0.150226), complex(0.050637,-0.048675), complex(-0.146730,-0.242599), complex(-0.335410,-0.424357), complex(-0.508703,-0.587785), complex(-0.661017,-0.727892), complex(-0.787984,-0.840945), complex(-0.886507,-0.924480), complex(-0.954748,-0.977268), complex(-0.992065,-0.999229), complex(-0.998908,-0.991308), complex(-0.976682,-0.955330), complex(-0.927592,-0.893841), complex(-0.854481,-0.809939), complex(-0.760661,-0.707107), complex(-0.649747,-0.589055), complex(-0.525509,-0.459580), complex(-0.391735,-0.322431), complex(-0.252112,-0.181206), complex(-0.110125,-0.039260), complex(0.031018,0.100362), complex(0.168446,0.234972), complex(0.299665,0.362275), complex(0.422579,0.480377), complex(0.535495,0.587785), complex(0.637121,0.683401), complex(0.726545,0.766493), complex(0.803208,0.836669), complex(0.866875,0.893841), complex(0.917599,0.938191), complex(0.955677,0.970127), complex(0.981619,0.990244), complex(0.996099,0.999289), complex(0.999926,0.998124), complex(0.994004,0.987688), complex(0.979302,0.968973), complex(0.956826,0.942991), complex(0.927592,0.910756), complex(0.892605,0.873262), complex(0.852845,0.831470), complex(0.809248,0.786288), complex(0.762697,0.738573), complex(0.714015,0.689114), complex(0.663959,0.638634), complex(0.613217,0.587785), complex(0.562408,0.537152), complex(0.512080,0.487250), complex(0.462716,0.438528), complex(0.414733,0.391374), complex(0.368490,0.346117), complex(0.324289,0.303035), complex(0.282383,0.262358), complex(0.242980,0.224271), complex(0.206247,0.188924), complex(0.172316,0.156434), complex(0.141290,0.126891), complex(0.113247,0.100362), complex(0.088242,0.076893), complex(0.066317,0.056519), complex(0.047499,0.039260), complex(0.031803,0.025130), complex(0.019241,0.014137), complex(0.009817,0.006283), complex(0.003534,0.001571), complex(0.000393,0.000000), complex(0.000393,0.001571), complex(0.003534,0.006283), complex(0.009817,0.014137), complex(0.019241,0.025130), complex(0.031803,0.039260), complex(0.047499,0.056519), complex(0.066317,0.076893), complex(0.088242,0.100362), complex(0.113247,0.126891), complex(0.141290,0.156434), complex(0.172316,0.188924), complex(0.206247,0.224271), complex(0.242980,0.262358), complex(0.282383,0.303035), complex(0.324289,0.346117), complex(0.368490,0.391374), complex(0.414733,0.438528), complex(0.462716,0.487250), complex(0.512080,0.537152), complex(0.562408,0.587785), complex(0.613217,0.638634), complex(0.663959,0.689114), complex(0.714015,0.738573), complex(0.762697,0.786288), complex(0.809248,0.831470), complex(0.852845,0.873262), complex(0.892605,0.910756), complex(0.927592,0.942991), complex(0.956826,0.968973), complex(0.979302,0.987688), complex(0.994004,0.998124), complex(0.999926,0.999289), complex(0.996099,0.990244), complex(0.981619,0.970127), complex(0.955677,0.938191), complex(0.917599,0.893841), complex(0.866875,0.836669), complex(0.803208,0.766493), complex(0.726545,0.683401), complex(0.637121,0.587785), complex(0.535495,0.480377), complex(0.422579,0.362275), complex(0.299665,0.234972), complex(0.168446,0.100362), complex(0.031018,-0.039260), complex(-0.110125,-0.181206), complex(-0.252112,-0.322431), complex(-0.391735,-0.459580), complex(-0.525509,-0.589055), complex(-0.649747,-0.707107), complex(-0.760661,-0.809939), complex(-0.854481,-0.893841), complex(-0.927592,-0.955330), complex(-0.976682,-0.991308), complex(-0.998908,-0.999229), complex(-0.992065,-0.977268), complex(-0.954748,-0.924480), complex(-0.886507,-0.840945), complex(-0.787984,-0.727892), complex(-0.661017,-0.587785), complex(-0.508703,-0.424357), complex(-0.335410,-0.242599), complex(-0.146730,-0.048675), complex(0.050637,0.150226), complex(0.249070,0.346117), complex(0.440292,0.530511), complex(0.615696,0.694784), complex(0.766745,0.830596), complex(0.885414,0.930354), complex(0.964661,0.987688), complex(0.998908,0.997927), complex(0.984496,0.958522), complex(0.920078,0.869409), complex(0.806935,0.733255), complex(0.649149,0.555570), complex(0.453641,0.344643), complex(0.230007,0.111295), complex(-0.009817,-0.131564), complex(-0.252112,-0.369585), complex(-0.482098,-0.587785), complex(-0.684833,-0.771514), complex(-0.846216,-0.907484), complex(-0.954044,-0.984838), complex(-0.999050,-0.996134), complex(-0.975831,-0.938191), complex(-0.883582,-0.812694), complex(-0.726545,-0.626468), complex(-0.514103,-0.391374), complex(-0.260462,-0.123775), complex(0.016100,0.156434), complex(0.294416,0.427200), complex(0.551973,0.666012), complex(0.766745,0.851818), complex(0.919153,0.967001), complex(0.994004,0.999229), complex(0.982214,0.942991), complex(0.882106,0.800627), complex(0.700131,0.582690), complex(0.450839,0.307523), complex(0.156047,0.000000), complex(-0.156822,-0.310511), complex(-0.457137,-0.592857), complex(-0.714015,-0.817245), complex(-0.899577,-0.958522), complex(-0.992164,-0.999229), complex(-0.979143,-0.932071), complex(-0.858938,-0.761425), complex(-0.641952,-0.503623), complex(-0.350167,-0.185838), complex(-0.015315,0.156434), complex(0.324289,0.483130), complex(0.627997,0.754251), complex(0.857729,0.934888), complex(0.982943,0.999980), complex(0.985042,0.938191), complex(0.860542,0.754251), complex(0.622480,0.469317), complex(0.299665,0.119097), complex(-0.066317,-0.250211), complex(-0.426135,-0.587785), complex(-0.729237,-0.845169), complex(-0.931072,-0.983445), complex(-0.999952,-0.979540), complex(-0.922521,-0.830596), complex(-0.706829,-0.555570), complex(-0.382321,-0.193549), complex(0.003534,0.201249), complex(0.391735,0.567269), complex(0.720581,0.845169), complex(0.935583,0.987688), complex(0.998871,0.968191), complex(0.896467,0.786288), complex(0.641952,0.469317), complex(0.275595,0.069060), complex(-0.141290,-0.346117), complex(-0.536158,-0.702650), complex(-0.837743,-0.934888), complex(-0.989177,-0.997613), complex(-0.959302,-0.875549), complex(-0.749851,-0.587785), complex(-0.396787,-0.185838), complex(0.034943,0.254771), complex(0.462716,0.648253), complex(0.801802,0.915241), complex(0.982361,0.999229), complex(0.964454,0.879316), complex(0.747769,0.576290), complex(0.373595,0.150226), complex(-0.081982,-0.310511), complex(-0.522833,-0.707107), complex(-0.852845,-0.951541), complex(-0.997188,-0.986686), complex(-0.920078,-0.800627), complex(-0.634697,-0.431456), complex(-0.202403,0.039260), complex(0.279368,0.503623), complex(0.698447,0.851818), complex(0.954044,0.998402), complex(0.981619,0.904157), complex(0.770263,0.587785), complex(0.367759,0.123775), complex(-0.128839,-0.373959), complex(-0.595699,-0.779447), complex(-0.912852,-0.986686), complex(-0.995525,-0.938191), complex(-0.817924,-0.642253), complex(-0.422579,-0.173476), complex(0.088242,0.344643), complex(0.577893,0.771514), complex(0.911565,0.987688), complex(0.993918,0.929197), complex(0.797558,0.607930), complex(0.373595,0.111295), complex(-0.159924,-0.420086), complex(-0.649747,-0.831470), complex(-0.951178,-0.999289), complex(-0.971539,-0.869409), complex(-0.700131,-0.476238), complex(-0.214693,0.064358), complex(0.339107,0.587785), complex(0.790396,0.930354), complex(0.995888,0.981091), complex(0.886507,0.719219), complex(0.492386,0.224271), complex(-0.063182,-0.346117), complex(-0.600734,-0.805308), complex(-0.942072,-0.998815), complex(-0.970031,-0.857527), complex(-0.670394,-0.424357), complex(-0.140512,0.156434), complex(0.440292,0.685691), complex(0.870377,0.977268), complex(0.996099,0.924480), complex(0.768256,0.541121), complex(0.263494,-0.039260), complex(-0.339107,-0.607930), complex(-0.820177,-0.955330), complex(-0.999952,-0.949096), complex(-0.806935,-0.586514), complex(-0.308643,0.000000))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10*2e6
  states: {}
- name: UConn2402_CrossCorrDown_0
  id: UConn2402_CrossCorrDown
  parameters: {}
  states: {}
- name: UConn2402_CrossCorrUp_0
  id: UConn2402_CrossCorrUp
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Chirp Vector
    repeat: 'True'
    type: complex
    vector: Chirp
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Up Chirp Corr"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Down Chirp Corr"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [UConn2402_CrossCorrDown_0, '0', qtgui_time_sink_x_1_0, '0']
- [UConn2402_CrossCorrUp_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vector_source_x_0, '0', UConn2402_CrossCorrDown_0, '0']
- [blocks_vector_source_x_0, '0', UConn2402_CrossCorrUp_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
