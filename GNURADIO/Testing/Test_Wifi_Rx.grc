options:
  parameters:
    generate_options: no_gui
    id: Test_Wifi_Rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: encoding
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '5890000000'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '.8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '.8'
  states: {}
- name: UConn2402_ArbitrarySync2_0
  id: UConn2402_ArbitrarySync2
  parameters:
    samples: '20000'
    threshold: '0.8'
  states: {}
- name: UConn2402_LFMChirpXCorr_0
  id: UConn2402_LFMChirpXCorr
  parameters:
    B: '2000000'
    dur: '.000040'
    samp_rate: '5000000'
  states: {}
- name: UConn2402_fftXCorr_0
  id: UConn2402_fftXCorr
  parameters:
    file: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_0.csv
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    dst_mac: '[0x30, 0x14, 0x4a, 0xe6, 0x46, 0xe4]'
    src_mac: '[0x12, 0x34, 0x56, 0x78, 0x90, 0xab]'
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    type: UDP_CLIENT
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: rx_gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: samp_rate
    chan_est: ieee802_11.Equalizer(chan_est)
    encoding: ieee802_11.Encoding(encoding)
    frequency: freq
    sensitivity: '0.56'
  states: {}

connections:
- [UConn2402_ArbitrarySync2_0, '0', wifi_phy_hier_0, '0']
- [UConn2402_LFMChirpXCorr_0, '0', blocks_null_sink_1, '0']
- [UConn2402_LFMChirpXCorr_0, '1', UConn2402_ArbitrarySync2_0, '1']
- [UConn2402_fftXCorr_0, '0', UConn2402_ArbitrarySync2_0, '1']
- [ieee802_11_mac_0, app out, UConn2402_ArbitrarySync2_0, stop]
- [ieee802_11_mac_0, app out, network_socket_pdu_0_0, pdus]
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [uhd_usrp_source_0, '0', UConn2402_ArbitrarySync2_0, '0']
- [uhd_usrp_source_0, '0', UConn2402_LFMChirpXCorr_0, '0']
- [uhd_usrp_source_0, '0', UConn2402_fftXCorr_0, '0']
- [wifi_phy_hier_0, '0', blocks_null_sink_0, '0']
- [wifi_phy_hier_0, mac_out, ieee802_11_mac_0, phy in]

metadata:
  file_format: 1
