options:
  parameters:
    generate_options: qt_gui
    id: Test_Wifi_Tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cfo
  id: variable_qtgui_range
  parameters:
    label: CFO
    start: '0'
    step: '1000'
    stop: 50e3
    value: '0'
  states: {}
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: encoding
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '5890000000'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    start: '0'
    step: '.1'
    stop: '2'
    value: '0'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: UConn2402_Chirp_0_0
  id: UConn2402_Chirp
  parameters:
    B: '2000000'
    chirp_op: '0'
    dur: '.000040'
    minoutbuf: '100000'
    pcklen: '"packet_len"'
    samp_rate: '5000000'
  states: {state: disabled}
- name: UConn2402_Preamble_0
  id: UConn2402_Preamble
  parameters:
    file: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_0.csv
    minoutbuf: '100000'
    pcklen: '"packet_len"'
  states: {}
- name: UConn2402_StatusMessage_0
  id: UConn2402_StatusMessage
  parameters:
    n: '1000'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("Message")
    period: '100'
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    minoutbuf: '100000'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    minoutbuf: '100000'
    noise_voltage: noise
    seed: '0'
    taps: 1.0 + 1.0j
  states: {state: disabled}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    dst_mac: '[0x30, 0x14, 0x4a, 0xe6, 0x46, 0xe4]'
    src_mac: '[0x12, 0x34, 0x56, 0x78, 0x90, 0xab]'
  states: {}
- name: uhd_usrp_sink_0_1_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq + cfo
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: '"packet_len"'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: samp_rate
    chan_est: ieee802_11.Equalizer(chan_est)
    encoding: ieee802_11.Encoding(encoding)
    frequency: freq
    sensitivity: '0.56'
  states: {}

connections:
- [UConn2402_Chirp_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [UConn2402_Preamble_0, '0', channels_channel_model_0, '0']
- [UConn2402_Preamble_0, '0', uhd_usrp_sink_0_1_0, '0']
- [UConn2402_StatusMessage_0, status, ieee802_11_mac_0, app in]
- [blocks_message_strobe_0, strobe, UConn2402_StatusMessage_0, strobe]
- [blocks_multiply_const_vxx_0_0_0, '0', UConn2402_Preamble_0, '0']
- [blocks_null_source_0, '0', wifi_phy_hier_0, '0']
- [channels_channel_model_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [wifi_phy_hier_0, '0', UConn2402_Chirp_0_0, '0']
- [wifi_phy_hier_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [wifi_phy_hier_0, mac_out, ieee802_11_mac_0, phy in]

metadata:
  file_format: 1
