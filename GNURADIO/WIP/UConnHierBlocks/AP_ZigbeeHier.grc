options:
  parameters:
    generate_options: hb
    id: zigbeeAP
    output_language: python
    title: Zigbee Physical Layer
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "Linear Comb", "STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: encoding
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '5890000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '5890000000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: '.8'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[5e6, 10e6, 20e6]'
    type: real
    value: 5e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {state: disabled}
- name: tx_gain
  id: variable
  parameters:
    value: '.8'
  states: {}
- name: Messaging
  id: qtgui_tab_widget
  parameters:
    label0: Packet Messaging (press ENTER)
    num_tabs: '1'
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 5/4
    comment: Scale "packet_len" tag by 5/4 after resampling for USRP TSB
    lengthtagname: '"packet_len"'
    minoutbuf: 2**16
    type: complex
  states: {state: disabled}
- name: graph
  id: qtgui_tab_widget
  parameters:
    label0: Wifi
    label1: Zigbee
    num_tabs: '2'
  states: {state: disabled}
- name: ieee802_15_4_mac_0
  id: ieee802_15_4_mac
  parameters:
    debug: 'True'
    dst: '0xffff'
    dst_pan: '0x1aaa'
    fcf: '0x8841'
    seq_nr: '0'
    src: '0x3344'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: ieee802_15_4_rime_stack_0
  id: ieee802_15_4_rime_stack
  parameters:
    bc_channels: '[129]'
    rime_add: '[23,42]'
    ruc_channels: '[132]'
    uc_channels: '[131]'
  states: {}
- name: note_0
  id: note
  parameters:
    note: For Debugging ONLY
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: msg_out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: msg_in
    type: message
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: 4MHz to 5MHz
    decim: '4'
    interp: '5'
    minoutbuf: 2**16
    type: ccc
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: msg_wifi
  states: {state: disabled}

connections:
- [blocks_tagged_stream_multiply_length_0, '0', pad_sink_0, '0']
- [ieee802_15_4_mac_0, app out, ieee802_15_4_rime_stack_0, fromMAC]
- [ieee802_15_4_mac_0, pdu out, ieee802_15_4_oqpsk_phy_0, txin]
- [ieee802_15_4_oqpsk_phy_0, '0', pad_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', rational_resampler_xxx_1, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, ieee802_15_4_mac_0, pdu in]
- [ieee802_15_4_rime_stack_0, bcout, pad_sink_1, in]
- [ieee802_15_4_rime_stack_0, toMAC, ieee802_15_4_mac_0, app in]
- [pad_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [pad_source_1, out, ieee802_15_4_rime_stack_0, bcin]
- [rational_resampler_xxx_1, '0', blocks_tagged_stream_multiply_length_0, '0']

metadata:
  file_format: 1
