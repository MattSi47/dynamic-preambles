options:
  parameters:
    generate_options: qt_gui
    id: Chirp_Corr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Chirp
  id: variable_qtgui_chooser
  parameters:
    label: Chirp
    label0: Up Chirp
    label1: Down Chirp
    num_opts: '2'
    option0: (complex(1,0), complex(6.21835e-05,-1), complex(-0.9998,-0.0200057), complex(-0.0597992,0.99821), complex(0.992863,0.119261), complex(0.197824,-0.980237), complex(-0.955745,-0.294195), complex(-0.405909,0.913914), complex(0.848732,0.528823), complex(0.656627,-0.754216), complex(-0.62525,-0.780424), complex(-0.888578,0.458726), complex(0.254945,0.966956), complex(0.999817,-0.0191353), complex(0.237122,-0.97148), complex(-0.8689,-0.494988), complex(-0.728496,0.68505), complex(0.42276,0.906241), complex(0.995161,-0.0982592), complex(0.25663,-0.96651), complex(-0.803666,-0.59508), complex(-0.859905,0.510455), complex(0.117841,0.993033), complex(0.949434,0.313966), complex(0.700952,-0.713208), complex(-0.311543,-0.950232), complex(-0.983787,-0.179339), complex(-0.642168,0.766564), complex(0.330255,0.943892), complex(0.975853,0.218428), complex(0.71517,-0.698951), complex(-0.176463,-0.984307), complex(-0.905162,-0.425067), complex(-0.879753,0.475431), complex(-0.16005,0.987109), complex(0.66983,0.742514), complex(0.999277,-0.0380146), complex(0.627093,-0.778945), complex(-0.156609,-0.987661), complex(-0.826268,-0.563277), complex(-0.980666,0.19569), complex(-0.563333,0.82623), complex(0.156486,0.98768), complex(0.778826,0.62724), complex(0.999287,-0.0377655), complex(0.742721,-0.6696), complex(0.160419,-0.987049), complex(-0.475046,-0.879961), complex(-0.904948,-0.425522), complex(-0.984406,0.175909), complex(-0.715605,0.698505), complex(-0.219099,0.975703), complex(0.329553,0.944137), complex(0.76604,0.642793), complex(0.983631,0.180197), complex(0.950523,-0.310653), complex(0.701663,-0.712509), complex(0.314971,-0.949101), complex(-0.116723,-0.993164), complex(-0.509441,-0.860505), complex(-0.802923,-0.596083), complex(-0.966174,-0.257892), complex(-0.995294,0.0968989), complex(-0.906848,0.421458), complex(-0.729518,0.683961), complex(-0.496339,0.868129), complex(-0.238691,0.971095), complex(0.0174496,0.999848), complex(0.253256,0.967399), complex(0.457122,0.889404), complex(0.623793,0.78159), complex(0.752953,0.658075), complex(0.847677,0.530513), complex(0.913078,0.407784), complex(0.955121,0.296217), complex(0.979805,0.199957), complex(0.992593,0.121488), complex(0.99807,0.0620949), complex(0.99975,0.0223724), complex(0.999997,0.00249211), complex(0.999997,0.00249211), complex(0.99975,0.0223724), complex(0.99807,0.0621025), complex(0.992593,0.121488), complex(0.979805,0.199957), complex(0.955121,0.296217), complex(0.913075,0.407791), complex(0.847677,0.530513), complex(0.752948,0.658081), complex(0.623793,0.78159), complex(0.457122,0.889404), complex(0.253263,0.967397), complex(0.0174572,0.999848), complex(-0.238699,0.971094), complex(-0.496339,0.868129), complex(-0.729521,0.683959), complex(-0.90685,0.421454), complex(-0.995295,0.0968913), complex(-0.966172,-0.2579), complex(-0.802923,-0.596083), complex(-0.509435,-0.860509), complex(-0.116723,-0.993164), complex(0.314978,-0.949099), complex(0.701663,-0.712509), complex(0.950523,-0.310653), complex(0.983631,0.180197), complex(0.76604,0.642793), complex(0.329546,0.94414), complex(-0.219099,0.975703), complex(-0.715605,0.698505), complex(-0.984408,0.175898), complex(-0.904952,-0.425515), complex(-0.475039,-0.879965), complex(0.160431,-0.987047), complex(0.742727,-0.669595), complex(0.999287,-0.0377541), complex(0.778824,0.627243), complex(0.156482,0.987681), complex(-0.563336,0.826228), complex(-0.980668,0.195678), complex(-0.826262,-0.563287), complex(-0.156598,-0.987662), complex(0.627101,-0.778938), complex(0.999277,-0.038007), complex(0.669816,0.742527), complex(-0.160065,0.987106), complex(-0.879758,0.475421), complex(-0.90516,-0.42507), complex(-0.176463,-0.984307), complex(0.71517,-0.698951), complex(0.975849,0.218447), complex(0.330259,0.94389), complex(-0.64218,0.766554), complex(-0.983787,-0.179339), complex(-0.311532,-0.950236), complex(0.700952,-0.713208), complex(0.949427,0.313987), complex(0.117843,0.993032), complex(-0.859908,0.51045), complex(-0.803657,-0.595092), complex(0.256637,-0.966508), complex(0.995161,-0.0982573), complex(0.42275,0.906246), complex(-0.728497,0.685049), complex(-0.868891,-0.495003), complex(0.237116,-0.971481), complex(0.999817,-0.0191258), complex(0.254958,0.966952), complex(-0.888587,0.458708), complex(-0.625253,-0.780422), complex(0.656632,-0.754211), complex(0.848729,0.528827), complex(-0.40592,0.913909), complex(-0.955742,-0.294204), complex(0.19784,-0.980234), complex(0.992865,0.119246), complex(-0.0598135,0.99821), complex(-0.9998,-0.0200121), complex(7.18395e-05,-1), complex(1,0))
    option1: (complex(1,0), complex(6.21835e-05,1), complex(-0.9998,0.0200057), complex(-0.0597992,-0.99821), complex(0.992863,-0.119261), complex(0.197824,0.980237), complex(-0.955745,0.294195), complex(-0.405909,-0.913914), complex(0.848732,-0.528823), complex(0.656627,0.754216), complex(-0.62525,0.780424), complex(-0.888578,-0.458726), complex(0.254945,-0.966956), complex(0.999817,0.0191353), complex(0.237122,0.97148), complex(-0.8689,0.494988), complex(-0.728496,-0.68505), complex(0.42276,-0.906241), complex(0.995161,0.0982592), complex(0.25663,0.96651), complex(-0.803666,0.59508), complex(-0.859905,-0.510455), complex(0.117841,-0.993033), complex(0.949434,-0.313966), complex(0.700952,0.713208), complex(-0.311543,0.950232), complex(-0.983787,0.179339), complex(-0.642168,-0.766564), complex(0.330255,-0.943892), complex(0.975853,-0.218428), complex(0.71517,0.698951), complex(-0.176463,0.984307), complex(-0.905162,0.425067), complex(-0.879753,-0.475431), complex(-0.16005,-0.987109), complex(0.66983,-0.742514), complex(0.999277,0.0380146), complex(0.627093,0.778945), complex(-0.156609,0.987661), complex(-0.826268,0.563277), complex(-0.980666,-0.19569), complex(-0.563333,-0.82623), complex(0.156486,-0.98768), complex(0.778826,-0.62724), complex(0.999287,0.0377655), complex(0.742721,0.6696), complex(0.160419,0.987049), complex(-0.475046,0.879961), complex(-0.904948,0.425522), complex(-0.984406,-0.175909), complex(-0.715605,-0.698505), complex(-0.219099,-0.975703), complex(0.329553,-0.944137), complex(0.76604,-0.642793), complex(0.983631,-0.180197), complex(0.950523,0.310653), complex(0.701663,0.712509), complex(0.314971,0.949101), complex(-0.116723,0.993164), complex(-0.509441,0.860505), complex(-0.802923,0.596083), complex(-0.966174,0.257892), complex(-0.995294,-0.0968989), complex(-0.906848,-0.421458), complex(-0.729518,-0.683961), complex(-0.496339,-0.868129), complex(-0.238691,-0.971095), complex(0.0174496,-0.999848), complex(0.253256,-0.967399), complex(0.457122,-0.889404), complex(0.623793,-0.78159), complex(0.752953,-0.658075), complex(0.847677,-0.530513), complex(0.913078,-0.407784), complex(0.955121,-0.296217), complex(0.979805,-0.199957), complex(0.992593,-0.121488), complex(0.99807,-0.0620949), complex(0.99975,-0.0223724), complex(0.999997,-0.00249211), complex(0.999997,-0.00249211), complex(0.99975,-0.0223724), complex(0.99807,-0.0621025), complex(0.992593,-0.121488), complex(0.979805,-0.199957), complex(0.955121,-0.296217), complex(0.913075,-0.407791), complex(0.847677,-0.530513), complex(0.752948,-0.658081), complex(0.623793,-0.78159), complex(0.457122,-0.889404), complex(0.253263,-0.967397), complex(0.0174572,-0.999848), complex(-0.238699,-0.971094), complex(-0.496339,-0.868129), complex(-0.729521,-0.683959), complex(-0.90685,-0.421454), complex(-0.995295,-0.0968913), complex(-0.966172,0.2579), complex(-0.802923,0.596083), complex(-0.509435,0.860509), complex(-0.116723,0.993164), complex(0.314978,0.949099), complex(0.701663,0.712509), complex(0.950523,0.310653), complex(0.983631,-0.180197), complex(0.76604,-0.642793), complex(0.329546,-0.94414), complex(-0.219099,-0.975703), complex(-0.715605,-0.698505), complex(-0.984408,-0.175898), complex(-0.904952,0.425515), complex(-0.475039,0.879965), complex(0.160431,0.987047), complex(0.742727,0.669595), complex(0.999287,0.0377541), complex(0.778824,-0.627243), complex(0.156482,-0.987681), complex(-0.563336,-0.826228), complex(-0.980668,-0.195678), complex(-0.826262,0.563287), complex(-0.156598,0.987662), complex(0.627101,0.778938), complex(0.999277,0.038007), complex(0.669816,-0.742527), complex(-0.160065,-0.987106), complex(-0.879758,-0.475421), complex(-0.90516,0.42507), complex(-0.176463,0.984307), complex(0.71517,0.698951), complex(0.975849,-0.218447), complex(0.330259,-0.94389), complex(-0.64218,-0.766554), complex(-0.983787,0.179339), complex(-0.311532,0.950236), complex(0.700952,0.713208), complex(0.949427,-0.313987), complex(0.117843,-0.993032), complex(-0.859908,-0.51045), complex(-0.803657,0.595092), complex(0.256637,0.966508), complex(0.995161,0.0982573), complex(0.42275,-0.906246), complex(-0.728497,-0.685049), complex(-0.868891,0.495003), complex(0.237116,0.971481), complex(0.999817,0.0191258), complex(0.254958,-0.966952), complex(-0.888587,-0.458708), complex(-0.625253,0.780422), complex(0.656632,0.754211), complex(0.848729,-0.528827), complex(-0.40592,-0.913909), complex(-0.955742,0.294204), complex(0.19784,0.980234), complex(0.992865,-0.119246), complex(-0.0598135,-0.99821), complex(-0.9998,0.0200121), complex(7.18395e-05,1), complex(1,0))
    type: raw
    value: (complex(1,0), complex(6.21835e-05,-1), complex(-0.9998,-0.0200057), complex(-0.0597992,0.99821), complex(0.992863,0.119261), complex(0.197824,-0.980237), complex(-0.955745,-0.294195), complex(-0.405909,0.913914), complex(0.848732,0.528823), complex(0.656627,-0.754216), complex(-0.62525,-0.780424), complex(-0.888578,0.458726), complex(0.254945,0.966956), complex(0.999817,-0.0191353), complex(0.237122,-0.97148), complex(-0.8689,-0.494988), complex(-0.728496,0.68505), complex(0.42276,0.906241), complex(0.995161,-0.0982592), complex(0.25663,-0.96651), complex(-0.803666,-0.59508), complex(-0.859905,0.510455), complex(0.117841,0.993033), complex(0.949434,0.313966), complex(0.700952,-0.713208), complex(-0.311543,-0.950232), complex(-0.983787,-0.179339), complex(-0.642168,0.766564), complex(0.330255,0.943892), complex(0.975853,0.218428), complex(0.71517,-0.698951), complex(-0.176463,-0.984307), complex(-0.905162,-0.425067), complex(-0.879753,0.475431), complex(-0.16005,0.987109), complex(0.66983,0.742514), complex(0.999277,-0.0380146), complex(0.627093,-0.778945), complex(-0.156609,-0.987661), complex(-0.826268,-0.563277), complex(-0.980666,0.19569), complex(-0.563333,0.82623), complex(0.156486,0.98768), complex(0.778826,0.62724), complex(0.999287,-0.0377655), complex(0.742721,-0.6696), complex(0.160419,-0.987049), complex(-0.475046,-0.879961), complex(-0.904948,-0.425522), complex(-0.984406,0.175909), complex(-0.715605,0.698505), complex(-0.219099,0.975703), complex(0.329553,0.944137), complex(0.76604,0.642793), complex(0.983631,0.180197), complex(0.950523,-0.310653), complex(0.701663,-0.712509), complex(0.314971,-0.949101), complex(-0.116723,-0.993164), complex(-0.509441,-0.860505), complex(-0.802923,-0.596083), complex(-0.966174,-0.257892), complex(-0.995294,0.0968989), complex(-0.906848,0.421458), complex(-0.729518,0.683961), complex(-0.496339,0.868129), complex(-0.238691,0.971095), complex(0.0174496,0.999848), complex(0.253256,0.967399), complex(0.457122,0.889404), complex(0.623793,0.78159), complex(0.752953,0.658075), complex(0.847677,0.530513), complex(0.913078,0.407784), complex(0.955121,0.296217), complex(0.979805,0.199957), complex(0.992593,0.121488), complex(0.99807,0.0620949), complex(0.99975,0.0223724), complex(0.999997,0.00249211), complex(0.999997,0.00249211), complex(0.99975,0.0223724), complex(0.99807,0.0621025), complex(0.992593,0.121488), complex(0.979805,0.199957), complex(0.955121,0.296217), complex(0.913075,0.407791), complex(0.847677,0.530513), complex(0.752948,0.658081), complex(0.623793,0.78159), complex(0.457122,0.889404), complex(0.253263,0.967397), complex(0.0174572,0.999848), complex(-0.238699,0.971094), complex(-0.496339,0.868129), complex(-0.729521,0.683959), complex(-0.90685,0.421454), complex(-0.995295,0.0968913), complex(-0.966172,-0.2579), complex(-0.802923,-0.596083), complex(-0.509435,-0.860509), complex(-0.116723,-0.993164), complex(0.314978,-0.949099), complex(0.701663,-0.712509), complex(0.950523,-0.310653), complex(0.983631,0.180197), complex(0.76604,0.642793), complex(0.329546,0.94414), complex(-0.219099,0.975703), complex(-0.715605,0.698505), complex(-0.984408,0.175898), complex(-0.904952,-0.425515), complex(-0.475039,-0.879965), complex(0.160431,-0.987047), complex(0.742727,-0.669595), complex(0.999287,-0.0377541), complex(0.778824,0.627243), complex(0.156482,0.987681), complex(-0.563336,0.826228), complex(-0.980668,0.195678), complex(-0.826262,-0.563287), complex(-0.156598,-0.987662), complex(0.627101,-0.778938), complex(0.999277,-0.038007), complex(0.669816,0.742527), complex(-0.160065,0.987106), complex(-0.879758,0.475421), complex(-0.90516,-0.42507), complex(-0.176463,-0.984307), complex(0.71517,-0.698951), complex(0.975849,0.218447), complex(0.330259,0.94389), complex(-0.64218,0.766554), complex(-0.983787,-0.179339), complex(-0.311532,-0.950236), complex(0.700952,-0.713208), complex(0.949427,0.313987), complex(0.117843,0.993032), complex(-0.859908,0.51045), complex(-0.803657,-0.595092), complex(0.256637,-0.966508), complex(0.995161,-0.0982573), complex(0.42275,0.906246), complex(-0.728497,0.685049), complex(-0.868891,-0.495003), complex(0.237116,-0.971481), complex(0.999817,-0.0191258), complex(0.254958,0.966952), complex(-0.888587,0.458708), complex(-0.625253,-0.780422), complex(0.656632,-0.754211), complex(0.848729,0.528827), complex(-0.40592,0.913909), complex(-0.955742,-0.294204), complex(0.19784,-0.980234), complex(0.992865,0.119246), complex(-0.0598135,0.99821), complex(-0.9998,-0.0200121), complex(7.18395e-05,-1), complex(1,0))
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '.05'
    stop: '1'
    value: '.8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: UConn2402_ArbitrarySync_0
  id: UConn2402_ArbitrarySync
  parameters:
    samples: '190'
    threshold: '0.8'
  states: {}
- name: UConn2402_Chirp_0
  id: UConn2402_Chirp
  parameters:
    B: '2000000'
    chirp_op: '1'
    dur: '.000040'
    pcklen: '"packet_len"'
    samp_rate: '4000000'
  states: {}
- name: UConn2402_LFMChirpXCorr_0
  id: UConn2402_LFMChirpXCorr
  parameters:
    B: '2000000'
    dur: '.000040'
    samp_rate: '4000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '-2'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '30'
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'True'
    type: complex
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0,0,0,0,0,0,0,0,0,0)*3
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: CorrUp
    label2: CorrDown
    name: '"Chirp Corr"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_4
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    tr_level: '0.9'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate/2
    center_freq0: 2.4e9
    gain0: gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate/2
    center_freq0: 2.4e9
    gain0: gain
    gain_type0: normalized
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [UConn2402_ArbitrarySync_0, '0', qtgui_time_sink_x_4, '0']
- [UConn2402_Chirp_0, '0', blocks_tag_gate_0, '0']
- [UConn2402_Chirp_0, '0', qtgui_time_sink_x_0, '0']
- [UConn2402_Chirp_0, '0', uhd_usrp_sink_0, '0']
- [UConn2402_LFMChirpXCorr_0, '0', UConn2402_ArbitrarySync_0, '1']
- [UConn2402_LFMChirpXCorr_0, '0', qtgui_time_sink_x_1, '0']
- [UConn2402_LFMChirpXCorr_0, '1', qtgui_time_sink_x_1, '1']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_random_source_x_0, '0', blocks_int_to_float_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_mag_squared_0, '0', UConn2402_LFMChirpXCorr_0, '1']
- [blocks_float_to_complex_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_int_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_stream_to_tagged_stream_0, '0', UConn2402_Chirp_0, '0']
- [blocks_tag_gate_0, '0', UConn2402_ArbitrarySync_0, '0']
- [blocks_tag_gate_0, '0', UConn2402_LFMChirpXCorr_0, '0']
- [blocks_tag_gate_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_vector_source_x_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [uhd_usrp_source_0, '0', UConn2402_LFMChirpXCorr_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_2, '0']

metadata:
  file_format: 1
