options:
  parameters:
    generate_options: qt_gui
    id: Example_NewBlocks
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: filepath
  id: variable_qtgui_chooser
  parameters:
    label: preamble
    label0: UpChirp
    label1: test
    num_opts: '2'
    option0: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/WIP/UpChirp.csv
    option1: test
    orient: Qt.QHBoxLayout
    type: string
    value: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/WIP/UpChirp.csv
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: UConn2402_Chirp_0
  id: UConn2402_Chirp
  parameters:
    B: '2000000'
    chirp_op: '1'
    dur: '.000040'
    pcklen: '"packet_len"'
    samp_rate: '5000000'
  states: {}
- name: UConn2402_LFMChirpXCorr_0
  id: UConn2402_LFMChirpXCorr
  parameters:
    B: '2000000'
    dur: '.000040'
    samp_rate: '5000000'
  states: {}
- name: UConn2402_Preamble_0
  id: UConn2402_Preamble
  parameters:
    comment: |-
      Change file path for your computer
       (.../dynamic-preambles/GNURADIO/WIP/UpChirp.csv)
    file: filepath
    pcklen: '"packet_len"'
  states: {}
- name: UConn2402_fftXCorr_0
  id: UConn2402_fftXCorr
  parameters:
    comment: |-
      Change file path for your computer
       (.../dynamic-preambles/GNURADIO/WIP/UpChirp.csv)
    file: filepath
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '15'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0, 0, 0)*5
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"New Block Preamble"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Up Chirp
    label2: Down Chirp
    name: '"Old Correlation"'
    nconnections: '2'
    size: '1024'
    srate: '5000000'
    tr_delay: '.000040'
    tr_level: '.8'
    type: float
    ylabel: ''
    ymax: '1.1'
    ymin: '-.1'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Up Chirp
    name: '"New Block Correlation"'
    size: '1024'
    srate: '5000000'
    tr_delay: '.000040'
    tr_level: '.8'
    type: float
    ylabel: ''
    ymax: '1.1'
    ymin: '-.1'
  states: {}

connections:
- [UConn2402_Chirp_0, '0', blocks_throttle_0_0, '0']
- [UConn2402_LFMChirpXCorr_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [UConn2402_LFMChirpXCorr_0, '1', qtgui_time_sink_x_1_0_0, '1']
- [UConn2402_Preamble_0, '0', blocks_throttle_0, '0']
- [UConn2402_fftXCorr_0, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', UConn2402_Chirp_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', UConn2402_Preamble_0, '0']
- [blocks_throttle_0, '0', UConn2402_LFMChirpXCorr_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0_0, '0', UConn2402_fftXCorr_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
