options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: transceiver_OQPSK
    output_language: python
    title: IEEE 802.15.4 Transceiver using OQPSK PHY
  states: {}

blocks:
- name: Chirp
  id: variable_qtgui_chooser
  parameters:
    label: Chirp
    label0: Up Chirp
    label1: Down Chirp
    num_opts: '2'
    option0: (complex(1,0), complex(6.21835e-05,-1), complex(-0.9998,-0.0200057), complex(-0.0597992,0.99821), complex(0.992863,0.119261), complex(0.197824,-0.980237), complex(-0.955745,-0.294195), complex(-0.405909,0.913914), complex(0.848732,0.528823), complex(0.656627,-0.754216), complex(-0.62525,-0.780424), complex(-0.888578,0.458726), complex(0.254945,0.966956), complex(0.999817,-0.0191353), complex(0.237122,-0.97148), complex(-0.8689,-0.494988), complex(-0.728496,0.68505), complex(0.42276,0.906241), complex(0.995161,-0.0982592), complex(0.25663,-0.96651), complex(-0.803666,-0.59508), complex(-0.859905,0.510455), complex(0.117841,0.993033), complex(0.949434,0.313966), complex(0.700952,-0.713208), complex(-0.311543,-0.950232), complex(-0.983787,-0.179339), complex(-0.642168,0.766564), complex(0.330255,0.943892), complex(0.975853,0.218428), complex(0.71517,-0.698951), complex(-0.176463,-0.984307), complex(-0.905162,-0.425067), complex(-0.879753,0.475431), complex(-0.16005,0.987109), complex(0.66983,0.742514), complex(0.999277,-0.0380146), complex(0.627093,-0.778945), complex(-0.156609,-0.987661), complex(-0.826268,-0.563277), complex(-0.980666,0.19569), complex(-0.563333,0.82623), complex(0.156486,0.98768), complex(0.778826,0.62724), complex(0.999287,-0.0377655), complex(0.742721,-0.6696), complex(0.160419,-0.987049), complex(-0.475046,-0.879961), complex(-0.904948,-0.425522), complex(-0.984406,0.175909), complex(-0.715605,0.698505), complex(-0.219099,0.975703), complex(0.329553,0.944137), complex(0.76604,0.642793), complex(0.983631,0.180197), complex(0.950523,-0.310653), complex(0.701663,-0.712509), complex(0.314971,-0.949101), complex(-0.116723,-0.993164), complex(-0.509441,-0.860505), complex(-0.802923,-0.596083), complex(-0.966174,-0.257892), complex(-0.995294,0.0968989), complex(-0.906848,0.421458), complex(-0.729518,0.683961), complex(-0.496339,0.868129), complex(-0.238691,0.971095), complex(0.0174496,0.999848), complex(0.253256,0.967399), complex(0.457122,0.889404), complex(0.623793,0.78159), complex(0.752953,0.658075), complex(0.847677,0.530513), complex(0.913078,0.407784), complex(0.955121,0.296217), complex(0.979805,0.199957), complex(0.992593,0.121488), complex(0.99807,0.0620949), complex(0.99975,0.0223724), complex(0.999997,0.00249211), complex(0.999997,0.00249211), complex(0.99975,0.0223724), complex(0.99807,0.0621025), complex(0.992593,0.121488), complex(0.979805,0.199957), complex(0.955121,0.296217), complex(0.913075,0.407791), complex(0.847677,0.530513), complex(0.752948,0.658081), complex(0.623793,0.78159), complex(0.457122,0.889404), complex(0.253263,0.967397), complex(0.0174572,0.999848), complex(-0.238699,0.971094), complex(-0.496339,0.868129), complex(-0.729521,0.683959), complex(-0.90685,0.421454), complex(-0.995295,0.0968913), complex(-0.966172,-0.2579), complex(-0.802923,-0.596083), complex(-0.509435,-0.860509), complex(-0.116723,-0.993164), complex(0.314978,-0.949099), complex(0.701663,-0.712509), complex(0.950523,-0.310653), complex(0.983631,0.180197), complex(0.76604,0.642793), complex(0.329546,0.94414), complex(-0.219099,0.975703), complex(-0.715605,0.698505), complex(-0.984408,0.175898), complex(-0.904952,-0.425515), complex(-0.475039,-0.879965), complex(0.160431,-0.987047), complex(0.742727,-0.669595), complex(0.999287,-0.0377541), complex(0.778824,0.627243), complex(0.156482,0.987681), complex(-0.563336,0.826228), complex(-0.980668,0.195678), complex(-0.826262,-0.563287), complex(-0.156598,-0.987662), complex(0.627101,-0.778938), complex(0.999277,-0.038007), complex(0.669816,0.742527), complex(-0.160065,0.987106), complex(-0.879758,0.475421), complex(-0.90516,-0.42507), complex(-0.176463,-0.984307), complex(0.71517,-0.698951), complex(0.975849,0.218447), complex(0.330259,0.94389), complex(-0.64218,0.766554), complex(-0.983787,-0.179339), complex(-0.311532,-0.950236), complex(0.700952,-0.713208), complex(0.949427,0.313987), complex(0.117843,0.993032), complex(-0.859908,0.51045), complex(-0.803657,-0.595092), complex(0.256637,-0.966508), complex(0.995161,-0.0982573), complex(0.42275,0.906246), complex(-0.728497,0.685049), complex(-0.868891,-0.495003), complex(0.237116,-0.971481), complex(0.999817,-0.0191258), complex(0.254958,0.966952), complex(-0.888587,0.458708), complex(-0.625253,-0.780422), complex(0.656632,-0.754211), complex(0.848729,0.528827), complex(-0.40592,0.913909), complex(-0.955742,-0.294204), complex(0.19784,-0.980234), complex(0.992865,0.119246), complex(-0.0598135,0.99821), complex(-0.9998,-0.0200121), complex(7.18395e-05,-1), complex(1,0))
    option1: (complex(1,0), complex(6.21835e-05,1), complex(-0.9998,0.0200057), complex(-0.0597992,-0.99821), complex(0.992863,-0.119261), complex(0.197824,0.980237), complex(-0.955745,0.294195), complex(-0.405909,-0.913914), complex(0.848732,-0.528823), complex(0.656627,0.754216), complex(-0.62525,0.780424), complex(-0.888578,-0.458726), complex(0.254945,-0.966956), complex(0.999817,0.0191353), complex(0.237122,0.97148), complex(-0.8689,0.494988), complex(-0.728496,-0.68505), complex(0.42276,-0.906241), complex(0.995161,0.0982592), complex(0.25663,0.96651), complex(-0.803666,0.59508), complex(-0.859905,-0.510455), complex(0.117841,-0.993033), complex(0.949434,-0.313966), complex(0.700952,0.713208), complex(-0.311543,0.950232), complex(-0.983787,0.179339), complex(-0.642168,-0.766564), complex(0.330255,-0.943892), complex(0.975853,-0.218428), complex(0.71517,0.698951), complex(-0.176463,0.984307), complex(-0.905162,0.425067), complex(-0.879753,-0.475431), complex(-0.16005,-0.987109), complex(0.66983,-0.742514), complex(0.999277,0.0380146), complex(0.627093,0.778945), complex(-0.156609,0.987661), complex(-0.826268,0.563277), complex(-0.980666,-0.19569), complex(-0.563333,-0.82623), complex(0.156486,-0.98768), complex(0.778826,-0.62724), complex(0.999287,0.0377655), complex(0.742721,0.6696), complex(0.160419,0.987049), complex(-0.475046,0.879961), complex(-0.904948,0.425522), complex(-0.984406,-0.175909), complex(-0.715605,-0.698505), complex(-0.219099,-0.975703), complex(0.329553,-0.944137), complex(0.76604,-0.642793), complex(0.983631,-0.180197), complex(0.950523,0.310653), complex(0.701663,0.712509), complex(0.314971,0.949101), complex(-0.116723,0.993164), complex(-0.509441,0.860505), complex(-0.802923,0.596083), complex(-0.966174,0.257892), complex(-0.995294,-0.0968989), complex(-0.906848,-0.421458), complex(-0.729518,-0.683961), complex(-0.496339,-0.868129), complex(-0.238691,-0.971095), complex(0.0174496,-0.999848), complex(0.253256,-0.967399), complex(0.457122,-0.889404), complex(0.623793,-0.78159), complex(0.752953,-0.658075), complex(0.847677,-0.530513), complex(0.913078,-0.407784), complex(0.955121,-0.296217), complex(0.979805,-0.199957), complex(0.992593,-0.121488), complex(0.99807,-0.0620949), complex(0.99975,-0.0223724), complex(0.999997,-0.00249211), complex(0.999997,-0.00249211), complex(0.99975,-0.0223724), complex(0.99807,-0.0621025), complex(0.992593,-0.121488), complex(0.979805,-0.199957), complex(0.955121,-0.296217), complex(0.913075,-0.407791), complex(0.847677,-0.530513), complex(0.752948,-0.658081), complex(0.623793,-0.78159), complex(0.457122,-0.889404), complex(0.253263,-0.967397), complex(0.0174572,-0.999848), complex(-0.238699,-0.971094), complex(-0.496339,-0.868129), complex(-0.729521,-0.683959), complex(-0.90685,-0.421454), complex(-0.995295,-0.0968913), complex(-0.966172,0.2579), complex(-0.802923,0.596083), complex(-0.509435,0.860509), complex(-0.116723,0.993164), complex(0.314978,0.949099), complex(0.701663,0.712509), complex(0.950523,0.310653), complex(0.983631,-0.180197), complex(0.76604,-0.642793), complex(0.329546,-0.94414), complex(-0.219099,-0.975703), complex(-0.715605,-0.698505), complex(-0.984408,-0.175898), complex(-0.904952,0.425515), complex(-0.475039,0.879965), complex(0.160431,0.987047), complex(0.742727,0.669595), complex(0.999287,0.0377541), complex(0.778824,-0.627243), complex(0.156482,-0.987681), complex(-0.563336,-0.826228), complex(-0.980668,-0.195678), complex(-0.826262,0.563287), complex(-0.156598,0.987662), complex(0.627101,0.778938), complex(0.999277,0.038007), complex(0.669816,-0.742527), complex(-0.160065,-0.987106), complex(-0.879758,-0.475421), complex(-0.90516,0.42507), complex(-0.176463,0.984307), complex(0.71517,0.698951), complex(0.975849,-0.218447), complex(0.330259,-0.94389), complex(-0.64218,-0.766554), complex(-0.983787,0.179339), complex(-0.311532,0.950236), complex(0.700952,0.713208), complex(0.949427,-0.313987), complex(0.117843,-0.993032), complex(-0.859908,-0.51045), complex(-0.803657,0.595092), complex(0.256637,0.966508), complex(0.995161,0.0982573), complex(0.42275,-0.906246), complex(-0.728497,-0.685049), complex(-0.868891,0.495003), complex(0.237116,0.971481), complex(0.999817,0.0191258), complex(0.254958,-0.966952), complex(-0.888587,-0.458708), complex(-0.625253,0.780422), complex(0.656632,0.754211), complex(0.848729,-0.528827), complex(-0.40592,-0.913909), complex(-0.955742,0.294204), complex(0.19784,0.980234), complex(0.992865,-0.119246), complex(-0.0598135,-0.99821), complex(-0.9998,0.0200121), complex(7.18395e-05,1), complex(1,0))
    type: raw
    value: (complex(1,0), complex(6.21835e-05,-1), complex(-0.9998,-0.0200057), complex(-0.0597992,0.99821), complex(0.992863,0.119261), complex(0.197824,-0.980237), complex(-0.955745,-0.294195), complex(-0.405909,0.913914), complex(0.848732,0.528823), complex(0.656627,-0.754216), complex(-0.62525,-0.780424), complex(-0.888578,0.458726), complex(0.254945,0.966956), complex(0.999817,-0.0191353), complex(0.237122,-0.97148), complex(-0.8689,-0.494988), complex(-0.728496,0.68505), complex(0.42276,0.906241), complex(0.995161,-0.0982592), complex(0.25663,-0.96651), complex(-0.803666,-0.59508), complex(-0.859905,0.510455), complex(0.117841,0.993033), complex(0.949434,0.313966), complex(0.700952,-0.713208), complex(-0.311543,-0.950232), complex(-0.983787,-0.179339), complex(-0.642168,0.766564), complex(0.330255,0.943892), complex(0.975853,0.218428), complex(0.71517,-0.698951), complex(-0.176463,-0.984307), complex(-0.905162,-0.425067), complex(-0.879753,0.475431), complex(-0.16005,0.987109), complex(0.66983,0.742514), complex(0.999277,-0.0380146), complex(0.627093,-0.778945), complex(-0.156609,-0.987661), complex(-0.826268,-0.563277), complex(-0.980666,0.19569), complex(-0.563333,0.82623), complex(0.156486,0.98768), complex(0.778826,0.62724), complex(0.999287,-0.0377655), complex(0.742721,-0.6696), complex(0.160419,-0.987049), complex(-0.475046,-0.879961), complex(-0.904948,-0.425522), complex(-0.984406,0.175909), complex(-0.715605,0.698505), complex(-0.219099,0.975703), complex(0.329553,0.944137), complex(0.76604,0.642793), complex(0.983631,0.180197), complex(0.950523,-0.310653), complex(0.701663,-0.712509), complex(0.314971,-0.949101), complex(-0.116723,-0.993164), complex(-0.509441,-0.860505), complex(-0.802923,-0.596083), complex(-0.966174,-0.257892), complex(-0.995294,0.0968989), complex(-0.906848,0.421458), complex(-0.729518,0.683961), complex(-0.496339,0.868129), complex(-0.238691,0.971095), complex(0.0174496,0.999848), complex(0.253256,0.967399), complex(0.457122,0.889404), complex(0.623793,0.78159), complex(0.752953,0.658075), complex(0.847677,0.530513), complex(0.913078,0.407784), complex(0.955121,0.296217), complex(0.979805,0.199957), complex(0.992593,0.121488), complex(0.99807,0.0620949), complex(0.99975,0.0223724), complex(0.999997,0.00249211), complex(0.999997,0.00249211), complex(0.99975,0.0223724), complex(0.99807,0.0621025), complex(0.992593,0.121488), complex(0.979805,0.199957), complex(0.955121,0.296217), complex(0.913075,0.407791), complex(0.847677,0.530513), complex(0.752948,0.658081), complex(0.623793,0.78159), complex(0.457122,0.889404), complex(0.253263,0.967397), complex(0.0174572,0.999848), complex(-0.238699,0.971094), complex(-0.496339,0.868129), complex(-0.729521,0.683959), complex(-0.90685,0.421454), complex(-0.995295,0.0968913), complex(-0.966172,-0.2579), complex(-0.802923,-0.596083), complex(-0.509435,-0.860509), complex(-0.116723,-0.993164), complex(0.314978,-0.949099), complex(0.701663,-0.712509), complex(0.950523,-0.310653), complex(0.983631,0.180197), complex(0.76604,0.642793), complex(0.329546,0.94414), complex(-0.219099,0.975703), complex(-0.715605,0.698505), complex(-0.984408,0.175898), complex(-0.904952,-0.425515), complex(-0.475039,-0.879965), complex(0.160431,-0.987047), complex(0.742727,-0.669595), complex(0.999287,-0.0377541), complex(0.778824,0.627243), complex(0.156482,0.987681), complex(-0.563336,0.826228), complex(-0.980668,0.195678), complex(-0.826262,-0.563287), complex(-0.156598,-0.987662), complex(0.627101,-0.778938), complex(0.999277,-0.038007), complex(0.669816,0.742527), complex(-0.160065,0.987106), complex(-0.879758,0.475421), complex(-0.90516,-0.42507), complex(-0.176463,-0.984307), complex(0.71517,-0.698951), complex(0.975849,0.218447), complex(0.330259,0.94389), complex(-0.64218,0.766554), complex(-0.983787,-0.179339), complex(-0.311532,-0.950236), complex(0.700952,-0.713208), complex(0.949427,0.313987), complex(0.117843,0.993032), complex(-0.859908,0.51045), complex(-0.803657,-0.595092), complex(0.256637,-0.966508), complex(0.995161,-0.0982573), complex(0.42275,0.906246), complex(-0.728497,0.685049), complex(-0.868891,-0.495003), complex(0.237116,-0.971481), complex(0.999817,-0.0191258), complex(0.254958,0.966952), complex(-0.888587,0.458708), complex(-0.625253,-0.780422), complex(0.656632,-0.754211), complex(0.848729,0.528827), complex(-0.40592,0.913909), complex(-0.955742,-0.294204), complex(0.19784,-0.980234), complex(0.992865,0.119246), complex(-0.0598135,0.99821), complex(-0.9998,-0.0200121), complex(7.18395e-05,-1), complex(1,0))
  states: {}
- name: Chirp_0
  id: variable_qtgui_chooser
  parameters:
    label: Chirp
    label0: Up Chirp
    label1: Down Chirp
    num_opts: '2'
    option0: (complex(1,0), complex(6.21835e-05,-1), complex(-0.9998,-0.0200057), complex(-0.0597992,0.99821), complex(0.992863,0.119261), complex(0.197824,-0.980237), complex(-0.955745,-0.294195), complex(-0.405909,0.913914), complex(0.848732,0.528823), complex(0.656627,-0.754216), complex(-0.62525,-0.780424), complex(-0.888578,0.458726), complex(0.254945,0.966956), complex(0.999817,-0.0191353), complex(0.237122,-0.97148), complex(-0.8689,-0.494988), complex(-0.728496,0.68505), complex(0.42276,0.906241), complex(0.995161,-0.0982592), complex(0.25663,-0.96651), complex(-0.803666,-0.59508), complex(-0.859905,0.510455), complex(0.117841,0.993033), complex(0.949434,0.313966), complex(0.700952,-0.713208), complex(-0.311543,-0.950232), complex(-0.983787,-0.179339), complex(-0.642168,0.766564), complex(0.330255,0.943892), complex(0.975853,0.218428), complex(0.71517,-0.698951), complex(-0.176463,-0.984307), complex(-0.905162,-0.425067), complex(-0.879753,0.475431), complex(-0.16005,0.987109), complex(0.66983,0.742514), complex(0.999277,-0.0380146), complex(0.627093,-0.778945), complex(-0.156609,-0.987661), complex(-0.826268,-0.563277), complex(-0.980666,0.19569), complex(-0.563333,0.82623), complex(0.156486,0.98768), complex(0.778826,0.62724), complex(0.999287,-0.0377655), complex(0.742721,-0.6696), complex(0.160419,-0.987049), complex(-0.475046,-0.879961), complex(-0.904948,-0.425522), complex(-0.984406,0.175909), complex(-0.715605,0.698505), complex(-0.219099,0.975703), complex(0.329553,0.944137), complex(0.76604,0.642793), complex(0.983631,0.180197), complex(0.950523,-0.310653), complex(0.701663,-0.712509), complex(0.314971,-0.949101), complex(-0.116723,-0.993164), complex(-0.509441,-0.860505), complex(-0.802923,-0.596083), complex(-0.966174,-0.257892), complex(-0.995294,0.0968989), complex(-0.906848,0.421458), complex(-0.729518,0.683961), complex(-0.496339,0.868129), complex(-0.238691,0.971095), complex(0.0174496,0.999848), complex(0.253256,0.967399), complex(0.457122,0.889404), complex(0.623793,0.78159), complex(0.752953,0.658075), complex(0.847677,0.530513), complex(0.913078,0.407784), complex(0.955121,0.296217), complex(0.979805,0.199957), complex(0.992593,0.121488), complex(0.99807,0.0620949), complex(0.99975,0.0223724), complex(0.999997,0.00249211), complex(0.999997,0.00249211), complex(0.99975,0.0223724), complex(0.99807,0.0621025), complex(0.992593,0.121488), complex(0.979805,0.199957), complex(0.955121,0.296217), complex(0.913075,0.407791), complex(0.847677,0.530513), complex(0.752948,0.658081), complex(0.623793,0.78159), complex(0.457122,0.889404), complex(0.253263,0.967397), complex(0.0174572,0.999848), complex(-0.238699,0.971094), complex(-0.496339,0.868129), complex(-0.729521,0.683959), complex(-0.90685,0.421454), complex(-0.995295,0.0968913), complex(-0.966172,-0.2579), complex(-0.802923,-0.596083), complex(-0.509435,-0.860509), complex(-0.116723,-0.993164), complex(0.314978,-0.949099), complex(0.701663,-0.712509), complex(0.950523,-0.310653), complex(0.983631,0.180197), complex(0.76604,0.642793), complex(0.329546,0.94414), complex(-0.219099,0.975703), complex(-0.715605,0.698505), complex(-0.984408,0.175898), complex(-0.904952,-0.425515), complex(-0.475039,-0.879965), complex(0.160431,-0.987047), complex(0.742727,-0.669595), complex(0.999287,-0.0377541), complex(0.778824,0.627243), complex(0.156482,0.987681), complex(-0.563336,0.826228), complex(-0.980668,0.195678), complex(-0.826262,-0.563287), complex(-0.156598,-0.987662), complex(0.627101,-0.778938), complex(0.999277,-0.038007), complex(0.669816,0.742527), complex(-0.160065,0.987106), complex(-0.879758,0.475421), complex(-0.90516,-0.42507), complex(-0.176463,-0.984307), complex(0.71517,-0.698951), complex(0.975849,0.218447), complex(0.330259,0.94389), complex(-0.64218,0.766554), complex(-0.983787,-0.179339), complex(-0.311532,-0.950236), complex(0.700952,-0.713208), complex(0.949427,0.313987), complex(0.117843,0.993032), complex(-0.859908,0.51045), complex(-0.803657,-0.595092), complex(0.256637,-0.966508), complex(0.995161,-0.0982573), complex(0.42275,0.906246), complex(-0.728497,0.685049), complex(-0.868891,-0.495003), complex(0.237116,-0.971481), complex(0.999817,-0.0191258), complex(0.254958,0.966952), complex(-0.888587,0.458708), complex(-0.625253,-0.780422), complex(0.656632,-0.754211), complex(0.848729,0.528827), complex(-0.40592,0.913909), complex(-0.955742,-0.294204), complex(0.19784,-0.980234), complex(0.992865,0.119246), complex(-0.0598135,0.99821), complex(-0.9998,-0.0200121), complex(7.18395e-05,-1), complex(1,0))
    option1: (complex(1,0), complex(6.21835e-05,1), complex(-0.9998,0.0200057), complex(-0.0597992,-0.99821), complex(0.992863,-0.119261), complex(0.197824,0.980237), complex(-0.955745,0.294195), complex(-0.405909,-0.913914), complex(0.848732,-0.528823), complex(0.656627,0.754216), complex(-0.62525,0.780424), complex(-0.888578,-0.458726), complex(0.254945,-0.966956), complex(0.999817,0.0191353), complex(0.237122,0.97148), complex(-0.8689,0.494988), complex(-0.728496,-0.68505), complex(0.42276,-0.906241), complex(0.995161,0.0982592), complex(0.25663,0.96651), complex(-0.803666,0.59508), complex(-0.859905,-0.510455), complex(0.117841,-0.993033), complex(0.949434,-0.313966), complex(0.700952,0.713208), complex(-0.311543,0.950232), complex(-0.983787,0.179339), complex(-0.642168,-0.766564), complex(0.330255,-0.943892), complex(0.975853,-0.218428), complex(0.71517,0.698951), complex(-0.176463,0.984307), complex(-0.905162,0.425067), complex(-0.879753,-0.475431), complex(-0.16005,-0.987109), complex(0.66983,-0.742514), complex(0.999277,0.0380146), complex(0.627093,0.778945), complex(-0.156609,0.987661), complex(-0.826268,0.563277), complex(-0.980666,-0.19569), complex(-0.563333,-0.82623), complex(0.156486,-0.98768), complex(0.778826,-0.62724), complex(0.999287,0.0377655), complex(0.742721,0.6696), complex(0.160419,0.987049), complex(-0.475046,0.879961), complex(-0.904948,0.425522), complex(-0.984406,-0.175909), complex(-0.715605,-0.698505), complex(-0.219099,-0.975703), complex(0.329553,-0.944137), complex(0.76604,-0.642793), complex(0.983631,-0.180197), complex(0.950523,0.310653), complex(0.701663,0.712509), complex(0.314971,0.949101), complex(-0.116723,0.993164), complex(-0.509441,0.860505), complex(-0.802923,0.596083), complex(-0.966174,0.257892), complex(-0.995294,-0.0968989), complex(-0.906848,-0.421458), complex(-0.729518,-0.683961), complex(-0.496339,-0.868129), complex(-0.238691,-0.971095), complex(0.0174496,-0.999848), complex(0.253256,-0.967399), complex(0.457122,-0.889404), complex(0.623793,-0.78159), complex(0.752953,-0.658075), complex(0.847677,-0.530513), complex(0.913078,-0.407784), complex(0.955121,-0.296217), complex(0.979805,-0.199957), complex(0.992593,-0.121488), complex(0.99807,-0.0620949), complex(0.99975,-0.0223724), complex(0.999997,-0.00249211), complex(0.999997,-0.00249211), complex(0.99975,-0.0223724), complex(0.99807,-0.0621025), complex(0.992593,-0.121488), complex(0.979805,-0.199957), complex(0.955121,-0.296217), complex(0.913075,-0.407791), complex(0.847677,-0.530513), complex(0.752948,-0.658081), complex(0.623793,-0.78159), complex(0.457122,-0.889404), complex(0.253263,-0.967397), complex(0.0174572,-0.999848), complex(-0.238699,-0.971094), complex(-0.496339,-0.868129), complex(-0.729521,-0.683959), complex(-0.90685,-0.421454), complex(-0.995295,-0.0968913), complex(-0.966172,0.2579), complex(-0.802923,0.596083), complex(-0.509435,0.860509), complex(-0.116723,0.993164), complex(0.314978,0.949099), complex(0.701663,0.712509), complex(0.950523,0.310653), complex(0.983631,-0.180197), complex(0.76604,-0.642793), complex(0.329546,-0.94414), complex(-0.219099,-0.975703), complex(-0.715605,-0.698505), complex(-0.984408,-0.175898), complex(-0.904952,0.425515), complex(-0.475039,0.879965), complex(0.160431,0.987047), complex(0.742727,0.669595), complex(0.999287,0.0377541), complex(0.778824,-0.627243), complex(0.156482,-0.987681), complex(-0.563336,-0.826228), complex(-0.980668,-0.195678), complex(-0.826262,0.563287), complex(-0.156598,0.987662), complex(0.627101,0.778938), complex(0.999277,0.038007), complex(0.669816,-0.742527), complex(-0.160065,-0.987106), complex(-0.879758,-0.475421), complex(-0.90516,0.42507), complex(-0.176463,0.984307), complex(0.71517,0.698951), complex(0.975849,-0.218447), complex(0.330259,-0.94389), complex(-0.64218,-0.766554), complex(-0.983787,0.179339), complex(-0.311532,0.950236), complex(0.700952,0.713208), complex(0.949427,-0.313987), complex(0.117843,-0.993032), complex(-0.859908,-0.51045), complex(-0.803657,0.595092), complex(0.256637,0.966508), complex(0.995161,0.0982573), complex(0.42275,-0.906246), complex(-0.728497,-0.685049), complex(-0.868891,0.495003), complex(0.237116,0.971481), complex(0.999817,0.0191258), complex(0.254958,-0.966952), complex(-0.888587,-0.458708), complex(-0.625253,0.780422), complex(0.656632,0.754211), complex(0.848729,-0.528827), complex(-0.40592,-0.913909), complex(-0.955742,0.294204), complex(0.19784,0.980234), complex(0.992865,-0.119246), complex(-0.0598135,-0.99821), complex(-0.9998,0.0200121), complex(7.18395e-05,1), complex(1,0))
    type: raw
    value: (complex(1,0), complex(6.21835e-05,-1), complex(-0.9998,-0.0200057), complex(-0.0597992,0.99821), complex(0.992863,0.119261), complex(0.197824,-0.980237), complex(-0.955745,-0.294195), complex(-0.405909,0.913914), complex(0.848732,0.528823), complex(0.656627,-0.754216), complex(-0.62525,-0.780424), complex(-0.888578,0.458726), complex(0.254945,0.966956), complex(0.999817,-0.0191353), complex(0.237122,-0.97148), complex(-0.8689,-0.494988), complex(-0.728496,0.68505), complex(0.42276,0.906241), complex(0.995161,-0.0982592), complex(0.25663,-0.96651), complex(-0.803666,-0.59508), complex(-0.859905,0.510455), complex(0.117841,0.993033), complex(0.949434,0.313966), complex(0.700952,-0.713208), complex(-0.311543,-0.950232), complex(-0.983787,-0.179339), complex(-0.642168,0.766564), complex(0.330255,0.943892), complex(0.975853,0.218428), complex(0.71517,-0.698951), complex(-0.176463,-0.984307), complex(-0.905162,-0.425067), complex(-0.879753,0.475431), complex(-0.16005,0.987109), complex(0.66983,0.742514), complex(0.999277,-0.0380146), complex(0.627093,-0.778945), complex(-0.156609,-0.987661), complex(-0.826268,-0.563277), complex(-0.980666,0.19569), complex(-0.563333,0.82623), complex(0.156486,0.98768), complex(0.778826,0.62724), complex(0.999287,-0.0377655), complex(0.742721,-0.6696), complex(0.160419,-0.987049), complex(-0.475046,-0.879961), complex(-0.904948,-0.425522), complex(-0.984406,0.175909), complex(-0.715605,0.698505), complex(-0.219099,0.975703), complex(0.329553,0.944137), complex(0.76604,0.642793), complex(0.983631,0.180197), complex(0.950523,-0.310653), complex(0.701663,-0.712509), complex(0.314971,-0.949101), complex(-0.116723,-0.993164), complex(-0.509441,-0.860505), complex(-0.802923,-0.596083), complex(-0.966174,-0.257892), complex(-0.995294,0.0968989), complex(-0.906848,0.421458), complex(-0.729518,0.683961), complex(-0.496339,0.868129), complex(-0.238691,0.971095), complex(0.0174496,0.999848), complex(0.253256,0.967399), complex(0.457122,0.889404), complex(0.623793,0.78159), complex(0.752953,0.658075), complex(0.847677,0.530513), complex(0.913078,0.407784), complex(0.955121,0.296217), complex(0.979805,0.199957), complex(0.992593,0.121488), complex(0.99807,0.0620949), complex(0.99975,0.0223724), complex(0.999997,0.00249211), complex(0.999997,0.00249211), complex(0.99975,0.0223724), complex(0.99807,0.0621025), complex(0.992593,0.121488), complex(0.979805,0.199957), complex(0.955121,0.296217), complex(0.913075,0.407791), complex(0.847677,0.530513), complex(0.752948,0.658081), complex(0.623793,0.78159), complex(0.457122,0.889404), complex(0.253263,0.967397), complex(0.0174572,0.999848), complex(-0.238699,0.971094), complex(-0.496339,0.868129), complex(-0.729521,0.683959), complex(-0.90685,0.421454), complex(-0.995295,0.0968913), complex(-0.966172,-0.2579), complex(-0.802923,-0.596083), complex(-0.509435,-0.860509), complex(-0.116723,-0.993164), complex(0.314978,-0.949099), complex(0.701663,-0.712509), complex(0.950523,-0.310653), complex(0.983631,0.180197), complex(0.76604,0.642793), complex(0.329546,0.94414), complex(-0.219099,0.975703), complex(-0.715605,0.698505), complex(-0.984408,0.175898), complex(-0.904952,-0.425515), complex(-0.475039,-0.879965), complex(0.160431,-0.987047), complex(0.742727,-0.669595), complex(0.999287,-0.0377541), complex(0.778824,0.627243), complex(0.156482,0.987681), complex(-0.563336,0.826228), complex(-0.980668,0.195678), complex(-0.826262,-0.563287), complex(-0.156598,-0.987662), complex(0.627101,-0.778938), complex(0.999277,-0.038007), complex(0.669816,0.742527), complex(-0.160065,0.987106), complex(-0.879758,0.475421), complex(-0.90516,-0.42507), complex(-0.176463,-0.984307), complex(0.71517,-0.698951), complex(0.975849,0.218447), complex(0.330259,0.94389), complex(-0.64218,0.766554), complex(-0.983787,-0.179339), complex(-0.311532,-0.950236), complex(0.700952,-0.713208), complex(0.949427,0.313987), complex(0.117843,0.993032), complex(-0.859908,0.51045), complex(-0.803657,-0.595092), complex(0.256637,-0.966508), complex(0.995161,-0.0982573), complex(0.42275,0.906246), complex(-0.728497,0.685049), complex(-0.868891,-0.495003), complex(0.237116,-0.971481), complex(0.999817,-0.0191258), complex(0.254958,0.966952), complex(-0.888587,0.458708), complex(-0.625253,-0.780422), complex(0.656632,-0.754211), complex(0.848729,0.528827), complex(-0.40592,0.913909), complex(-0.955742,-0.294204), complex(0.19784,-0.980234), complex(0.992865,0.119246), complex(-0.0598135,0.99821), complex(-0.9998,-0.0200121), complex(7.18395e-05,-1), complex(1,0))
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: RX Channel
    labels: '[str(i) for i in range(11, 27)]'
    num_opts: '0'
    options: '[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)]'
    type: real
    value: '2480000000'
  states: {}
- name: freq_0
  id: variable_qtgui_chooser
  parameters:
    label: TX Channel
    labels: '[str(i) for i in range(11, 27)]'
    num_opts: '0'
    options: '[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)]'
    type: real
    value: '2480000000'
  states: {}
- name: noise_lvl
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.1'
    stop: '2.8'
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: UConn2402_Chirp_0
  id: UConn2402_Chirp
  parameters:
    B: '2000000'
    chirp_op: '1'
    dur: '.000040'
    minoutbuf: '40000'
    pcklen: '"packet_len"'
    samp_rate: '4000000'
  states: {}
- name: UConn2402_LFMChirpXCorr_0
  id: UConn2402_LFMChirpXCorr
  parameters:
    B: '2000000'
    dur: '.000040'
    samp_rate: '4000000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/sensor.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("Hello World! Hello World!\n")
    period: '1000'
  states: {}
- name: foo_packet_pad_0
  id: foo_packet_pad
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    pad_front: '2000'
    pad_tail: '2000'
  states: {state: disabled}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'True'
    tech: '195'
  states: {state: disabled}
- name: ieee802_15_4_mac_0
  id: ieee802_15_4_mac
  parameters:
    debug: 'True'
    dst: '0xffff'
    dst_pan: '0x1aaa'
    fcf: '0x8841'
    seq_nr: '0'
    src: '0x3344'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: ieee802_15_4_rime_stack_0
  id: ieee802_15_4_rime_stack
  parameters:
    bc_channels: '[129]'
    rime_add: '[23,42]'
    ruc_channels: '[132]'
    uc_channels: '[131]'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: nc -u localhost 52001
    mtu: '10000'
    port: '52001'
    type: UDP_SERVER
  states: {state: disabled}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    comment: nc -u -l 127.0.0.2 52002
    host: 127.0.0.2
    mtu: '10000'
    port: '52002'
    type: UDP_CLIENT
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: CorrUp
    label2: CorrDown
    name: '"Chirp Corr"'
    nconnections: '2'
    size: '1024'
    srate: '4000000'
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '150'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '4000000'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 2e6
    center_freq0: freq_0
    gain0: '0.75'
    gain_type0: normalized
    len_tag_name: packet_len
    samp_rate: 4e6
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 2e6
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: disabled
    dev_addr: ''
    dev_args: '""'
    gain0: rx_gain
    gain_type0: normalized
    iq_imbal_enb0: disabled
    samp_rate: '4000000'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [UConn2402_Chirp_0, '0', qtgui_time_sink_x_0_0, '0']
- [UConn2402_Chirp_0, '0', uhd_usrp_sink_0, '0']
- [UConn2402_LFMChirpXCorr_0, '0', qtgui_time_sink_x_1, '0']
- [UConn2402_LFMChirpXCorr_0, '1', qtgui_time_sink_x_1, '1']
- [blocks_complex_to_mag_squared_0, '0', UConn2402_LFMChirpXCorr_0, '1']
- [blocks_message_strobe_0, strobe, ieee802_15_4_rime_stack_0, bcin]
- [foo_packet_pad_0, '0', UConn2402_LFMChirpXCorr_0, '0']
- [foo_packet_pad_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_15_4_mac_0, app out, ieee802_15_4_rime_stack_0, fromMAC]
- [ieee802_15_4_mac_0, pdu out, foo_wireshark_connector_0, in]
- [ieee802_15_4_mac_0, pdu out, ieee802_15_4_oqpsk_phy_0, txin]
- [ieee802_15_4_oqpsk_phy_0, '0', UConn2402_Chirp_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', foo_packet_pad_0, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, ieee802_15_4_mac_0, pdu in]
- [ieee802_15_4_rime_stack_0, bcout, blocks_message_debug_0, print]
- [ieee802_15_4_rime_stack_0, bcout, network_socket_pdu_1, pdus]
- [ieee802_15_4_rime_stack_0, toMAC, ieee802_15_4_mac_0, app in]
- [network_socket_pdu_0, pdus, ieee802_15_4_rime_stack_0, bcin]
- [uhd_usrp_source_0, '0', UConn2402_LFMChirpXCorr_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_2, '0']

metadata:
  file_format: 1
