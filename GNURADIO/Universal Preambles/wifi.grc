options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: wifi
    output_language: python
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "Linear Comb", "STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: encoding
  id: variable
  parameters:
    value: '0'
  states: {}
- name: filepath
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'Messaging@0: 0,0'
    label: Preamble
    label0: Preamble 1
    label1: Preamble 2
    label2: Preamble 3
    num_opts: '3'
    option0: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_0.csv
    option1: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_1.csv
    option2: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_2.csv
    orient: Qt.QHBoxLayout
    type: string
    value: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_0.csv
    widget: radio_buttons
  states: {}
- name: filepath2
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'Messaging@1: 0,0'
    label: Preamble
    label0: Preamble 1
    label1: Preamble 2
    label2: Preamble 3
    num_opts: '3'
    option0: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_0.csv
    option1: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_1.csv
    option2: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_2.csv
    orient: Qt.QHBoxLayout
    type: string
    value: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_0.csv
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '5890000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '5890000000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: '.8'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[5e6, 10e6, 20e6]'
    type: real
    value: 5e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {state: disabled}
- name: tx_gain
  id: variable
  parameters:
    value: '.8'
  states: {}
- name: Messaging
  id: qtgui_tab_widget
  parameters:
    label0: Device 1
    label1: Device 2
    num_tabs: '2'
  states: {}
- name: UConn2402_ArbitrarySync2_0
  id: UConn2402_ArbitrarySync2
  parameters:
    samples: '20000'
    threshold: '0.8'
  states: {}
- name: UConn2402_ArbitrarySync2_0_0
  id: UConn2402_ArbitrarySync2
  parameters:
    samples: '20000'
    threshold: '0.8'
  states: {}
- name: UConn2402_GUIMessagePrefixer_0
  id: UConn2402_GUIMessagePrefixer
  parameters:
    prefix: 'Wifi-Device1: '
  states: {}
- name: UConn2402_GUIMessagePrefixer_0_0
  id: UConn2402_GUIMessagePrefixer
  parameters:
    prefix: 'Wifi-Device2: '
  states: {}
- name: UConn2402_Preamble_0
  id: UConn2402_Preamble
  parameters:
    file: filepath
    minoutbuf: '100000'
    pcklen: '"packet_len"'
  states: {}
- name: UConn2402_Preamble_0_0
  id: UConn2402_Preamble
  parameters:
    file: filepath2
    minoutbuf: '100000'
    pcklen: '"packet_len"'
  states: {}
- name: UConn2402_StatusMessage_0
  id: UConn2402_StatusMessage
  parameters:
    n: '0'
  states: {}
- name: UConn2402_StatusMessage_0_0
  id: UConn2402_StatusMessage
  parameters:
    n: '0'
  states: {}
- name: UConn2402_fftXCorr_0
  id: UConn2402_fftXCorr
  parameters:
    file: filepath
  states: {}
- name: UConn2402_fftXCorr_0_0
  id: UConn2402_fftXCorr
  parameters:
    file: filepath2
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_POISSON
    mean: '3000'
    msg: pmt.intern("Wifi-Device1")
    std: '3000'
  states: {}
- name: blocks_message_strobe_random_0_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_POISSON
    mean: '3000'
    msg: pmt.intern("Wifi-Device2")
    std: '3000'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    minoutbuf: '100000'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    minoutbuf: '100000'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    dst_mac: '[0x30, 0x14, 0x4a, 0xe6, 0x46, 0xe4]'
    src_mac: '[0x12, 0x34, 0x56, 0x78, 0x90, 0xab]'
  states: {}
- name: ieee802_11_mac_0_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    dst_mac: '[0x30, 0x14, 0x4a, 0xe6, 0x46, 0xe4]'
    src_mac: '[0x12, 0x34, 0x56, 0x78, 0x90, 0xab]'
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_0_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    type: UDP_CLIENT
  states: {}
- name: note_0
  id: note
  parameters:
    note: Debug ONLY
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 'Messaging@0: 1,0'
    is_pair: 'False'
    key: pressed
    label: Send Wifi Message (RF0)
    type: string
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 'Messaging@1: 1,0'
    is_pair: 'False'
    key: pressed
    label: Send Wifi Message (RF1)
    type: string
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    color1: black
    color2: magenta
    gui_hint: 'Messaging@0: 3,0'
    label1: I
    label2: Q
    name: '"Packet (Tx)"'
    size: '1024'
    srate: 5e6
    tr_delay: '.000020'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    color2: magenta
    gui_hint: 'Messaging@1: 3,0'
    label1: I
    label2: Q
    name: '"Packet (Tx)"'
    size: '1024'
    srate: 5e6
    tr_delay: '.000020'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'Messaging@0: 2,0'
    label1: Preamble
    legend: 'False'
    name: '"Correlation (Rx)"'
    size: '1024'
    srate: '5000000'
    tr_delay: '.000040'
    tr_level: '.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: ''
    ymax: '1.1'
    ymin: '-.1'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'Messaging@1: 2,0'
    label1: Preamble
    legend: 'False'
    name: '"Correlation (Rx)"'
    size: '1024'
    srate: '5000000'
    tr_delay: '.000040'
    tr_level: '.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: ''
    ymax: '1.1'
    ymin: '-.1'
  states: {}
- name: uhd_usrp_sink_0_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: freq
    center_freq1: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: tx_gain
    gain1: tx_gain
    gain_type0: normalized
    gain_type1: normalized
    len_tag_name: '"packet_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_1_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: freq
    center_freq1: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: tx_gain
    gain1: tx_gain
    gain_type0: normalized
    gain_type1: normalized
    len_tag_name: '"packet_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: freq
    center_freq1: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: rx_gain
    gain1: rx_gain
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: samp_rate
    chan_est: ieee802_11.Equalizer(chan_est)
    encoding: ieee802_11.Encoding(encoding)
    frequency: freq
    sensitivity: '0.56'
  states: {}
- name: wifi_phy_hier_0_0
  id: wifi_phy_hier
  parameters:
    bandwidth: samp_rate
    chan_est: ieee802_11.Equalizer(chan_est)
    encoding: ieee802_11.Encoding(encoding)
    frequency: freq
    sensitivity: '0.56'
  states: {}

connections:
- [UConn2402_ArbitrarySync2_0, '0', wifi_phy_hier_0, '0']
- [UConn2402_ArbitrarySync2_0_0, '0', wifi_phy_hier_0_0, '0']
- [UConn2402_GUIMessagePrefixer_0, clear, qtgui_edit_box_msg_0, val]
- [UConn2402_GUIMessagePrefixer_0, msg_out, ieee802_11_mac_0, app in]
- [UConn2402_GUIMessagePrefixer_0_0, clear, qtgui_edit_box_msg_0_0, val]
- [UConn2402_GUIMessagePrefixer_0_0, msg_out, ieee802_11_mac_0_0, app in]
- [UConn2402_Preamble_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [UConn2402_Preamble_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [UConn2402_Preamble_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [UConn2402_Preamble_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [UConn2402_StatusMessage_0, status, ieee802_11_mac_0, app in]
- [UConn2402_StatusMessage_0_0, status, ieee802_11_mac_0_0, app in]
- [UConn2402_fftXCorr_0, '0', UConn2402_ArbitrarySync2_0, '1']
- [UConn2402_fftXCorr_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [UConn2402_fftXCorr_0_0, '0', UConn2402_ArbitrarySync2_0_0, '1']
- [UConn2402_fftXCorr_0_0, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [blocks_message_strobe_random_0, strobe, UConn2402_StatusMessage_0, strobe]
- [blocks_message_strobe_random_0_0, strobe, UConn2402_StatusMessage_0_0, strobe]
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_0_1, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', uhd_usrp_sink_0_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', uhd_usrp_sink_0_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', uhd_usrp_sink_0_1_0, '1']
- [ieee802_11_mac_0, app out, UConn2402_ArbitrarySync2_0, stop]
- [ieee802_11_mac_0, app out, network_socket_pdu_0_0, pdus]
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [ieee802_11_mac_0_0, app out, UConn2402_ArbitrarySync2_0_0, stop]
- [ieee802_11_mac_0_0, app out, network_socket_pdu_0_0_0, pdus]
- [ieee802_11_mac_0_0, phy out, wifi_phy_hier_0_0, mac_in]
- [qtgui_edit_box_msg_0, msg, UConn2402_GUIMessagePrefixer_0, msg_in]
- [qtgui_edit_box_msg_0_0, msg, UConn2402_GUIMessagePrefixer_0_0, msg_in]
- [uhd_usrp_source_0, '0', UConn2402_ArbitrarySync2_0, '0']
- [uhd_usrp_source_0, '0', UConn2402_fftXCorr_0, '0']
- [uhd_usrp_source_0, '1', UConn2402_ArbitrarySync2_0_0, '0']
- [uhd_usrp_source_0, '1', UConn2402_fftXCorr_0_0, '0']
- [wifi_phy_hier_0, '0', UConn2402_Preamble_0, '0']
- [wifi_phy_hier_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [wifi_phy_hier_0, mac_out, ieee802_11_mac_0, phy in]
- [wifi_phy_hier_0_0, '0', UConn2402_Preamble_0_0, '0']
- [wifi_phy_hier_0_0, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [wifi_phy_hier_0_0, mac_out, ieee802_11_mac_0_0, phy in]

metadata:
  file_format: 1
