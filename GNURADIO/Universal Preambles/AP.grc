options:
  parameters:
    generate_options: qt_gui
    id: AP
    output_language: python
    title: AP Control
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "Linear Comb", "STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: encoding
  id: variable
  parameters:
    value: '0'
  states: {}
- name: filepath_wifi
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'Messaging@0: 1,0'
    label: Preamble (Tx Only)
    label0: Preamble 1
    label1: Preamble 2
    label2: Preamble 3
    num_opts: '3'
    option0: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_0.csv
    option1: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_1.csv
    option2: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_2.csv
    orient: Qt.QHBoxLayout
    type: string
    value: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_0.csv
    widget: radio_buttons
  states: {}
- name: filepath_zigbee
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'Messaging@0: 1,1'
    label: Preamble (Tx Only)
    label0: Preamble 4
    label1: Preamble 5
    num_opts: '2'
    option0: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_3.csv
    option1: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_4.csv
    orient: Qt.QHBoxLayout
    type: string
    value: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_3.csv
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '5890000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '5890000000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: '.8'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[5e6, 10e6, 20e6]'
    type: real
    value: 5e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {state: disabled}
- name: tx_gain
  id: variable
  parameters:
    value: '.8'
  states: {}
- name: Messaging
  id: qtgui_tab_widget
  parameters:
    label0: Packet Messaging (press ENTER)
    num_tabs: '1'
  states: {}
- name: UConn2402_ArbitrarySync2_0
  id: UConn2402_ArbitrarySync2
  parameters:
    samples: '20000'
    threshold: '0.8'
  states: {}
- name: UConn2402_ArbitrarySync2_1
  id: UConn2402_ArbitrarySync2
  parameters:
    samples: '50000'
    threshold: '0.8'
  states: {}
- name: UConn2402_GUIMessagePrefixer_0
  id: UConn2402_GUIMessagePrefixer
  parameters:
    prefix: 'AP-Wifi: '
  states: {}
- name: UConn2402_GUIMessagePrefixer_0_0
  id: UConn2402_GUIMessagePrefixer
  parameters:
    prefix: 'AP-Zigbee: '
  states: {}
- name: UConn2402_Preamble_0
  id: UConn2402_Preamble
  parameters:
    file: filepath_wifi
    minoutbuf: '415488'
    pcklen: '"packet_len"'
  states: {}
- name: UConn2402_Preamble_1
  id: UConn2402_Preamble
  parameters:
    file: filepath_zigbee
    minoutbuf: 2**16
    pcklen: '"packet_len"'
  states: {}
- name: UConn2402_StatusMessage_0
  id: UConn2402_StatusMessage
  parameters:
    n: '100'
  states: {state: disabled}
- name: UConn2402_StatusMessage_0_0
  id: UConn2402_StatusMessage
  parameters:
    n: '100'
  states: {state: disabled}
- name: UConn2402_fftXCorr_0
  id: UConn2402_fftXCorr
  parameters:
    file: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_0.csv
  states: {}
- name: UConn2402_fftXCorr_0_0
  id: UConn2402_fftXCorr
  parameters:
    file: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_3.csv
  states: {}
- name: UConn2402_fftXCorr_0_1
  id: UConn2402_fftXCorr
  parameters:
    file: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_4.csv
  states: {}
- name: UConn2402_fftXCorr_1
  id: UConn2402_fftXCorr
  parameters:
    file: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_1.csv
  states: {}
- name: UConn2402_fftXCorr_2
  id: UConn2402_fftXCorr
  parameters:
    file: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_2.csv
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_int_0_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_int_0_1
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_int_0_2
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_int_0_2_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("AP BURST| 100pckt|")
    period: '1000'
  states: {state: disabled}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("AP BURST| 100pckt|")
    period: '1000'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.2'
    minoutbuf: '415488'
    type: complex
  states: {}
- name: blocks_or_xx_0
  id: blocks_or_xx
  parameters:
    num_inputs: '3'
    type: int
  states: {}
- name: blocks_or_xx_0_0
  id: blocks_or_xx
  parameters:
    type: int
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 5/4
    comment: Scale "packet_len" tag by 5/4 after resampling for USRP TSB
    lengthtagname: '"packet_len"'
    minoutbuf: 2**16
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.8'
    init: '0'
    low: '0.8'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.8'
    init: '0'
    low: '0.8'
  states: {}
- name: blocks_threshold_ff_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.8'
    init: '0'
    low: '0.8'
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: '0.8'
    init: '0'
    low: '0.8'
  states: {}
- name: blocks_threshold_ff_0_1_0
  id: blocks_threshold_ff
  parameters:
    high: '0.8'
    init: '0'
    low: '0.8'
  states: {}
- name: graph
  id: qtgui_tab_widget
  parameters:
    label0: Wifi
    label1: Zigbee
    num_tabs: '2'
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    dst_mac: '[0x30, 0x14, 0x4a, 0xe6, 0x46, 0xe4]'
    src_mac: '[0x12, 0x34, 0x56, 0x78, 0x90, 0xab]'
  states: {}
- name: ieee802_15_4_mac_0
  id: ieee802_15_4_mac
  parameters:
    debug: 'True'
    dst: '0xffff'
    dst_pan: '0x1aaa'
    fcf: '0x8841'
    seq_nr: '0'
    src: '0x3344'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: ieee802_15_4_rime_stack_0
  id: ieee802_15_4_rime_stack
  parameters:
    bc_channels: '[129]'
    rime_add: '[23,42]'
    ruc_channels: '[132]'
    uc_channels: '[131]'
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    comment: |-
      Combined 802.15.4 and 802.11 outputs
       (nc -u -l localhost 52001)
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    type: UDP_CLIENT
  states: {}
- name: note_0
  id: note
  parameters:
    note: For Debugging ONLY
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 'Messaging@0: 0,0'
    is_pair: 'False'
    key: pressed
    label: Send Wifi Message
    type: string
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 'Messaging@0: 0,1'
    is_pair: 'False'
    key: pressed
    label: Send Zigbee Message
    type: string
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    color1: black
    color2: magenta
    gui_hint: graph@0
    label1: I
    label2: Q
    name: '"Packet (Tx)"'
    size: '1024'
    srate: 5e6
    tr_delay: '.000020'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    color2: magenta
    gui_hint: graph@1
    label1: I
    label2: Q
    name: '"Packet"'
    size: '1024'
    srate: 5e6
    tr_delay: '.000020'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'graph@0: 0,0'
    label1: Preamble 1
    legend: 'False'
    marker1: '0'
    name: '"Preamble 1 Correlation (Rx)"'
    size: '1024'
    srate: '5000000'
    tr_delay: '.000040'
    tr_level: '.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: ''
    ymax: '1.1'
    ymin: '-.1'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: green
    gui_hint: 'graph@0: 0,1'
    label1: Preamble 2
    legend: 'False'
    marker1: '0'
    name: '"Preamble 2 Correlation (Rx)"'
    size: '1024'
    srate: '5000000'
    tr_delay: '.000040'
    tr_level: '.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: ''
    ymax: '1.1'
    ymin: '-.1'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: cyan
    gui_hint: 'graph@0: 0,2'
    label1: Preamble 3
    legend: 'False'
    marker1: '0'
    name: '"Preamble 3 Correlation (Rx)"'
    size: '1024'
    srate: '5000000'
    tr_delay: '.000040'
    tr_level: '.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: ''
    ymax: '1.1'
    ymin: '-.1'
  states: {}
- name: qtgui_time_sink_x_1_0_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'graph@1: 0,0'
    label1: Preamble 1
    legend: 'False'
    marker1: '0'
    name: '"Preamble 4 Correlation (Rx)"'
    size: '1024'
    srate: '5000000'
    tr_delay: '.000040'
    tr_level: '.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: ''
    ymax: '1.1'
    ymin: '-.1'
  states: {}
- name: qtgui_time_sink_x_1_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    color1: cyan
    gui_hint: 'graph@1: 0,1'
    label1: Preamble 1
    legend: 'False'
    marker1: '0'
    name: '"Preamble 5 Correlation (Rx)"'
    size: '1024'
    srate: '5000000'
    tr_delay: '.000040'
    tr_level: '.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: ''
    ymax: '1.1'
    ymin: '-.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 5 MHz to 4MHz
    decim: '5'
    interp: '4'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: 4MHz to 5MHz
    decim: '4'
    interp: '5'
    minoutbuf: 2**16
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: packet_len
    minoutbuf: 2**16
    samp_rate: 5e6
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: packet_len
    minoutbuf: '415488'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: rx_gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: msg_zigbee
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: msg_wifi
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: msg_wifi
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: msg_wifi
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: msg_zigbee
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: msg_zigbee
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: samp_rate
    chan_est: ieee802_11.Equalizer(chan_est)
    encoding: ieee802_11.Encoding(encoding)
    frequency: freq
    sensitivity: '0.56'
  states: {}

connections:
- [UConn2402_ArbitrarySync2_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [UConn2402_ArbitrarySync2_1, '0', wifi_phy_hier_0, '0']
- [UConn2402_GUIMessagePrefixer_0, clear, qtgui_edit_box_msg_0, val]
- [UConn2402_GUIMessagePrefixer_0, msg_out, ieee802_11_mac_0, app in]
- [UConn2402_GUIMessagePrefixer_0_0, clear, qtgui_edit_box_msg_0_0, val]
- [UConn2402_GUIMessagePrefixer_0_0, msg_out, ieee802_15_4_rime_stack_0, bcin]
- [UConn2402_Preamble_0, '0', blocks_multiply_const_vxx_0, '0']
- [UConn2402_Preamble_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [UConn2402_Preamble_1, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [UConn2402_Preamble_1, '0', uhd_usrp_sink_0, '0']
- [UConn2402_StatusMessage_0, status, ieee802_15_4_rime_stack_0, bcin]
- [UConn2402_StatusMessage_0_0, status, ieee802_11_mac_0, app in]
- [UConn2402_fftXCorr_0, '0', blocks_threshold_ff_0, '0']
- [UConn2402_fftXCorr_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [UConn2402_fftXCorr_0_0, '0', blocks_threshold_ff_0_1, '0']
- [UConn2402_fftXCorr_0_0, '0', qtgui_time_sink_x_1_0_0_1, '0']
- [UConn2402_fftXCorr_0_1, '0', blocks_threshold_ff_0_1_0, '0']
- [UConn2402_fftXCorr_0_1, '0', qtgui_time_sink_x_1_0_0_1_0, '0']
- [UConn2402_fftXCorr_1, '0', blocks_threshold_ff_0_0, '0']
- [UConn2402_fftXCorr_1, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [UConn2402_fftXCorr_2, '0', blocks_threshold_ff_0_0_0, '0']
- [UConn2402_fftXCorr_2, '0', qtgui_time_sink_x_1_0_0_0_0, '0']
- [blocks_float_to_int_0, '0', blocks_or_xx_0, '0']
- [blocks_float_to_int_0_0, '0', blocks_or_xx_0, '2']
- [blocks_float_to_int_0_1, '0', blocks_or_xx_0, '1']
- [blocks_float_to_int_0_2, '0', blocks_or_xx_0_0, '0']
- [blocks_float_to_int_0_2_0, '0', blocks_or_xx_0_0, '1']
- [blocks_int_to_float_0, '0', UConn2402_ArbitrarySync2_1, '1']
- [blocks_int_to_float_0_0, '0', UConn2402_ArbitrarySync2_0, '1']
- [blocks_message_strobe_0, strobe, UConn2402_StatusMessage_0, strobe]
- [blocks_message_strobe_0_0, strobe, UConn2402_StatusMessage_0_0, strobe]
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_or_xx_0, '0', blocks_int_to_float_0, '0']
- [blocks_or_xx_0_0, '0', blocks_int_to_float_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', UConn2402_Preamble_1, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_int_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_int_0_1, '0']
- [blocks_threshold_ff_0_0_0, '0', blocks_float_to_int_0_0, '0']
- [blocks_threshold_ff_0_1, '0', blocks_float_to_int_0_2, '0']
- [blocks_threshold_ff_0_1_0, '0', blocks_float_to_int_0_2_0, '0']
- [ieee802_11_mac_0, app out, virtual_sink_0_0, '0']
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [ieee802_15_4_mac_0, app out, ieee802_15_4_rime_stack_0, fromMAC]
- [ieee802_15_4_mac_0, pdu out, ieee802_15_4_oqpsk_phy_0, txin]
- [ieee802_15_4_oqpsk_phy_0, '0', rational_resampler_xxx_1, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, ieee802_15_4_mac_0, pdu in]
- [ieee802_15_4_rime_stack_0, bcout, virtual_sink_0, '0']
- [ieee802_15_4_rime_stack_0, toMAC, ieee802_15_4_mac_0, app in]
- [qtgui_edit_box_msg_0, msg, UConn2402_GUIMessagePrefixer_0, msg_in]
- [qtgui_edit_box_msg_0_0, msg, UConn2402_GUIMessagePrefixer_0_0, msg_in]
- [rational_resampler_xxx_0, '0', UConn2402_ArbitrarySync2_0, '0']
- [rational_resampler_xxx_1, '0', blocks_tagged_stream_multiply_length_0, '0']
- [uhd_usrp_source_0, '0', UConn2402_ArbitrarySync2_1, '0']
- [uhd_usrp_source_0, '0', UConn2402_fftXCorr_0, '0']
- [uhd_usrp_source_0, '0', UConn2402_fftXCorr_0_0, '0']
- [uhd_usrp_source_0, '0', UConn2402_fftXCorr_0_1, '0']
- [uhd_usrp_source_0, '0', UConn2402_fftXCorr_1, '0']
- [uhd_usrp_source_0, '0', UConn2402_fftXCorr_2, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_0, '0', network_socket_pdu_0_0, pdus]
- [virtual_source_0_0, '0', UConn2402_ArbitrarySync2_1, stop]
- [virtual_source_1, '0', network_socket_pdu_0_0, pdus]
- [virtual_source_1_0, '0', UConn2402_ArbitrarySync2_0, stop]
- [wifi_phy_hier_0, '0', UConn2402_Preamble_0, '0']
- [wifi_phy_hier_0, mac_out, ieee802_11_mac_0, phy in]

metadata:
  file_format: 1
