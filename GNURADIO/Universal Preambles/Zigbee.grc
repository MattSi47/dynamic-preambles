options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: Zigbee
    output_language: python
    title: IEEE 802.15.4 Transceiver using OQPSK PHY
  states: {}

blocks:
- name: filepath
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'Messaging@0: 0,0'
    label: Preamble
    label0: Preamble 4
    label1: Preamble 5
    num_opts: '2'
    option0: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_3.csv
    option1: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_4.csv
    orient: Qt.QHBoxLayout
    type: string
    value: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_3.csv
    widget: radio_buttons
  states: {}
- name: filepath2
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'Messaging@1: 0,0'
    label: Preamble
    label0: Preamble 4
    label1: Preamble 5
    num_opts: '2'
    option0: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_3.csv
    option1: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_4.csv
    orient: Qt.QHBoxLayout
    type: string
    value: /home/spencer/Documents/SeniorDesign/Git/dynamic-preambles/GNURADIO/Universal Preambles/Preambles/SigSet696_MonteCarlo1k_3.csv
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 6,0
    label: RX Channel
    labels: '[str(i) for i in range(11, 27)]'
    num_opts: '0'
    options: '[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)]'
    type: real
    value: '2480000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '5890000000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: '.8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {state: disabled}
- name: tx_gain
  id: variable
  parameters:
    value: '.8'
  states: {}
- name: Messaging
  id: qtgui_tab_widget
  parameters:
    label0: Device 1
    label1: Device 2
    num_tabs: '2'
  states: {}
- name: UConn2402_ArbitrarySync2_0
  id: UConn2402_ArbitrarySync2
  parameters:
    samples: '20000'
    threshold: '0.8'
  states: {}
- name: UConn2402_ArbitrarySync2_0_0
  id: UConn2402_ArbitrarySync2
  parameters:
    samples: '20000'
    threshold: '0.8'
  states: {}
- name: UConn2402_GUIMessagePrefixer_0
  id: UConn2402_GUIMessagePrefixer
  parameters:
    prefix: 'Zigbee-Device1: '
  states: {}
- name: UConn2402_GUIMessagePrefixer_0_0
  id: UConn2402_GUIMessagePrefixer
  parameters:
    prefix: 'Zigbee-Device2: '
  states: {}
- name: UConn2402_Preamble_0
  id: UConn2402_Preamble
  parameters:
    file: filepath
    minoutbuf: 2**16
    pcklen: '"packet_len"'
  states: {}
- name: UConn2402_Preamble_0_0
  id: UConn2402_Preamble
  parameters:
    file: filepath2
    minoutbuf: 2**16
    pcklen: '"packet_len"'
  states: {}
- name: UConn2402_StatusMessage_0
  id: UConn2402_StatusMessage
  parameters:
    n: '0'
  states: {}
- name: UConn2402_StatusMessage_0_0
  id: UConn2402_StatusMessage
  parameters:
    n: '0'
  states: {}
- name: UConn2402_fftXCorr_0
  id: UConn2402_fftXCorr
  parameters:
    file: filepath
  states: {}
- name: UConn2402_fftXCorr_0_0
  id: UConn2402_fftXCorr
  parameters:
    file: filepath2
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_POISSON
    mean: '3000'
    msg: pmt.intern("Zigbee-Device1")
    std: '3000'
  states: {}
- name: blocks_message_strobe_random_0_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_POISSON
    mean: '3000'
    msg: pmt.intern("Zigbee-Device2")
    std: '3000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 5/4
    comment: Scale "packet_len" tag by 5/4 after resampling for USRP TSB
    lengthtagname: '"packet_len"'
    minoutbuf: 2**16
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 5/4
    comment: Scale "packet_len" tag by 5/4 after resampling for USRP TSB
    lengthtagname: '"packet_len"'
    minoutbuf: 2**16
    type: complex
  states: {}
- name: ieee802_15_4_mac_0
  id: ieee802_15_4_mac
  parameters:
    debug: 'True'
    dst: '0xffff'
    dst_pan: '0x1aaa'
    fcf: '0x8841'
    seq_nr: '0'
    src: '0x3344'
  states: {}
- name: ieee802_15_4_mac_0_0
  id: ieee802_15_4_mac
  parameters:
    debug: 'True'
    dst: '0xffff'
    dst_pan: '0x1aaa'
    fcf: '0x8841'
    seq_nr: '0'
    src: '0x3344'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: ieee802_15_4_oqpsk_phy_0_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: ieee802_15_4_rime_stack_0
  id: ieee802_15_4_rime_stack
  parameters:
    bc_channels: '[129]'
    rime_add: '[23,42]'
    ruc_channels: '[132]'
    uc_channels: '[131]'
  states: {}
- name: ieee802_15_4_rime_stack_0_0
  id: ieee802_15_4_rime_stack
  parameters:
    bc_channels: '[129]'
    rime_add: '[23,42]'
    ruc_channels: '[132]'
    uc_channels: '[131]'
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    comment: nc -u -l localhost 52001
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_1_0
  id: network_socket_pdu
  parameters:
    comment: nc -u -l localhost 52002
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    type: UDP_CLIENT
  states: {}
- name: note_0
  id: note
  parameters:
    note: Debug ONLY
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 'Messaging@0: 1,0'
    is_pair: 'False'
    key: pressed
    label: Send Zigbee Message (RF0)
    type: string
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 'Messaging@1: 1,0'
    is_pair: 'False'
    key: pressed
    label: Send Zigbee Message (RF1)
    type: string
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    color1: black
    color2: magenta
    gui_hint: 'Messaging@0: 3,0'
    label1: I
    label2: Q
    name: '"Packet (Tx)"'
    size: '1024'
    srate: 5e6
    tr_delay: '.000020'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    color2: magenta
    gui_hint: 'Messaging@1: 3,0'
    label1: I
    label2: Q
    name: '"Packet (Tx)"'
    size: '1024'
    srate: 4e6
    tr_delay: '.000020'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'Messaging@0: 2,0'
    label1: Up Chirp
    legend: 'False'
    name: '"Correlation (Rx)"'
    size: '1024'
    srate: '5000000'
    tr_delay: '.000040'
    tr_level: '.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: ''
    ymax: '1.1'
    ymin: '-.1'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'Messaging@1: 2,0'
    label1: Up Chirp
    legend: 'False'
    name: '"Correlation (Rx)"'
    size: '1024'
    srate: '5000000'
    tr_delay: '.000040'
    tr_level: '.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: ''
    ymax: '1.1'
    ymin: '-.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 5 MHz to 4MHz
    decim: '5'
    interp: '4'
    type: ccf
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    comment: 5 MHz to 4MHz
    decim: '5'
    interp: '4'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: 4MHz to 5MHz
    decim: '4'
    interp: '5'
    minoutbuf: 2**16
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    comment: 4MHz to 5MHz
    decim: '4'
    interp: '5'
    minoutbuf: 2**16
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: freq
    center_freq1: freq
    gain0: tx_gain
    gain1: tx_gain
    gain_type0: normalized
    gain_type1: normalized
    len_tag_name: '"packet_len"'
    minoutbuf: 2**16
    nchan: '2'
    samp_rate: 5e6
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: freq
    center_freq1: freq
    gain0: tx_gain
    gain1: tx_gain
    gain_type0: normalized
    gain_type1: normalized
    len_tag_name: '"packet_len"'
    minoutbuf: 2**16
    nchan: '2'
    samp_rate: 5e6
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: freq
    center_freq1: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: rx_gain
    gain1: rx_gain
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [UConn2402_ArbitrarySync2_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [UConn2402_ArbitrarySync2_0_0, '0', ieee802_15_4_oqpsk_phy_0_0, '0']
- [UConn2402_GUIMessagePrefixer_0, clear, qtgui_edit_box_msg_0, val]
- [UConn2402_GUIMessagePrefixer_0, msg_out, ieee802_15_4_rime_stack_0, bcin]
- [UConn2402_GUIMessagePrefixer_0_0, clear, qtgui_edit_box_msg_0_0, val]
- [UConn2402_GUIMessagePrefixer_0_0, msg_out, ieee802_15_4_rime_stack_0_0, bcin]
- [UConn2402_Preamble_0, '0', blocks_multiply_const_vxx_0, '0']
- [UConn2402_Preamble_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [UConn2402_Preamble_0, '0', uhd_usrp_sink_0, '0']
- [UConn2402_Preamble_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [UConn2402_Preamble_0_0, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [UConn2402_Preamble_0_0, '0', uhd_usrp_sink_0_0, '1']
- [UConn2402_StatusMessage_0, status, ieee802_15_4_rime_stack_0, bcin]
- [UConn2402_StatusMessage_0_0, status, ieee802_15_4_rime_stack_0_0, bcin]
- [UConn2402_fftXCorr_0, '0', UConn2402_ArbitrarySync2_0, '1']
- [UConn2402_fftXCorr_0, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [UConn2402_fftXCorr_0_0, '0', UConn2402_ArbitrarySync2_0_0, '1']
- [UConn2402_fftXCorr_0_0, '0', qtgui_time_sink_x_1_0_0_0_1, '0']
- [blocks_message_strobe_random_0, strobe, UConn2402_StatusMessage_0, strobe]
- [blocks_message_strobe_random_0_0, strobe, UConn2402_StatusMessage_0_0, strobe]
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', UConn2402_Preamble_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', UConn2402_Preamble_0_0, '0']
- [ieee802_15_4_mac_0, app out, ieee802_15_4_rime_stack_0, fromMAC]
- [ieee802_15_4_mac_0, pdu out, ieee802_15_4_oqpsk_phy_0, txin]
- [ieee802_15_4_mac_0_0, app out, ieee802_15_4_rime_stack_0_0, fromMAC]
- [ieee802_15_4_mac_0_0, pdu out, ieee802_15_4_oqpsk_phy_0_0, txin]
- [ieee802_15_4_oqpsk_phy_0, '0', rational_resampler_xxx_1, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, ieee802_15_4_mac_0, pdu in]
- [ieee802_15_4_oqpsk_phy_0_0, '0', rational_resampler_xxx_1_0, '0']
- [ieee802_15_4_oqpsk_phy_0_0, rxout, ieee802_15_4_mac_0_0, pdu in]
- [ieee802_15_4_rime_stack_0, bcout, UConn2402_ArbitrarySync2_0, stop]
- [ieee802_15_4_rime_stack_0, bcout, network_socket_pdu_1, pdus]
- [ieee802_15_4_rime_stack_0, toMAC, ieee802_15_4_mac_0, app in]
- [ieee802_15_4_rime_stack_0_0, bcout, UConn2402_ArbitrarySync2_0_0, stop]
- [ieee802_15_4_rime_stack_0_0, bcout, network_socket_pdu_1_0, pdus]
- [ieee802_15_4_rime_stack_0_0, toMAC, ieee802_15_4_mac_0_0, app in]
- [qtgui_edit_box_msg_0, msg, UConn2402_GUIMessagePrefixer_0, msg_in]
- [qtgui_edit_box_msg_0_0, msg, UConn2402_GUIMessagePrefixer_0_0, msg_in]
- [rational_resampler_xxx_0, '0', UConn2402_ArbitrarySync2_0, '0']
- [rational_resampler_xxx_0_1, '0', UConn2402_ArbitrarySync2_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_tagged_stream_multiply_length_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [uhd_usrp_source_0_0, '0', UConn2402_fftXCorr_0, '0']
- [uhd_usrp_source_0_0, '0', rational_resampler_xxx_0, '0']
- [uhd_usrp_source_0_0, '1', UConn2402_fftXCorr_0_0, '0']
- [uhd_usrp_source_0_0, '1', rational_resampler_xxx_0_1, '0']

metadata:
  file_format: 1
